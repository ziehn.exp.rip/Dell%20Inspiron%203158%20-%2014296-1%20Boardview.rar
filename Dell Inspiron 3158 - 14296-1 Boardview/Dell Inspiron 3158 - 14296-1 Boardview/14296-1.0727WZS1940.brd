# Allegro board 14296-1.0727WZS1940.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI1_SO_ROM_R: length 13.9
  BOTTOM w0.114: R2513.2 EC2504.1 138.19,87.28 138.59,87.68 138.73,87.68 138.91,87.86 138.91,88.81 138.77,88.95 138.77,88.95 138.67,89.06 138.67,91.74 138.79,91.87 139.22,91.87 139.35,91.99 139.35,92.6 139.15,92.8 138.7,92.8 137.37,91.47 137.37,89.12 137.5,88.99 137.7,88.99 138,89.3 SPI252.2
SPI1_WP_ROM_R: length 16.6
  BOTTOM w0.114: R2514.2 135.52,87.65 135.77,87.9 136,87.9 136.13,87.78 136.13,84.88 136.24,84.77 136.48,84.77 136.61,84.89 136.61,85.16 136.73,85.29 137.07,85.29 137.19,85.16 137.19,84.89 137.32,84.77 137.98,84.77 138.11,84.89 v1(138.11,85.11) 138.11,85.33 137.98,85.46 137.69,85.46 137.58,85.57 137.57,85.57 137.35,85.79 136.86,85.79 136.73,85.92 136.73,87.8 136.86,87.93 138.29,87.93 138.54,88.18 138.54,88.35 138.41,88.47 136.71,88.47 136.58,88.6 136.58,88.78 136.73,88.93 SPI252.3
SPI_CLK_CPU: length 66.3
  L6 w0.102: v2(93.78,89.5) 93.81,89.53 94.39,89.53 95.36,90.49 95.36,92.72 99.96,97.33 100.85,97.33 103.76,100.23 105.81,100.23 107.91,100.23 111,103.32 111,107.28 111.44,107.71 112.5,107.71 v2(112.94,107.28)
  BOTTOM w0.089: 91.31,85.51 89.96,85.51 89.48,85.03 89.48,84.39 89.47,84.37 89.47,83.1 CPU1.AV2
  BOTTOM w0.114: 91.31,85.51 93.35,87.54 94.19,87.54 94.32,87.67 94.32,88.97 v2(93.78,89.5) ; R1806.2 135.16,101 135.16,101.4 134.66,101.91 129.26,101.91 128.42,102.74 128.21,102.96 125.35,102.96 124.98,103.33 124.98,103.33 123.97,104.34 117.15,104.34 114.46,107.03 114.46,107.16 114.33,107.28 v1(113.98,107.28) v2(112.94,107.28)
SPI_CLK_ROM: length 5.3
  TOP w0.114: v2(134.27,98.77) 134.21,98.84 R2511.2 ; R2511.2 R2505.2 ; R2511.2 133.32,98.77 R2404.1 133.32,97.44 v1(133.69,97.07)
  BOTTOM w0.114: v2(134.27,98.77) 134.81,99.31 134.87,99.31 R1806.1
SPI_CLK_ROM_EC: length 51.4
  TOP w0.114: R2485.1 161.7,59.36 160.39,60.67 160.38,60.67 156.01,65.04 155.74,65.04 147.4,73.38 147.4,73.9 140.73,80.57 140.73,81.8 140.37,82.16 139.1,82.16 138.6,82.66 138.6,83.97 137.51,85.06 137.51,91.96 136.97,92.5 136.86,92.5 136.18,93.19 136.18,95.7 v1(135.19,96.69) 134.21,97.67 R2404.2
SPI_CLK_ROM_R: length 16.9
  TOP w0.114: R2505.1 132.49,100.99 131.71,101.77 131.26,101.77 130.89,101.4 129.24,101.4 128.13,102.5 127.45,102.5 125.76,104.19 125.76,105 126.4,105.63 126.63,105.63 v1(127.24,106.24) 127.26,106.27 127.26,107.12 EC2503.1 126.71,107.66 v2(125.64,107.66)
  BOTTOM w0.114: SKT251.6 126.14,108.17 v2(125.64,107.66)
SPI_CS_CPU_N0: length 25.9
  TOP w0.114: R1812.2 93.76,87.37 94.09,87.04 94.09,86.53 93.96,86.4 93.27,86.4 92.81,85.94 92.39,85.94 92.26,86.07 92.26,86.53 93.1,87.37 v2(93.1,88.74)
  BOTTOM w0.089: CPU1.AU3 89.29,82.79 89.29,84.44 89.31,84.46 89.31,85.16 89.35,85.21
  BOTTOM w0.114: v2(93.1,88.74) 93.21,88.74 93.24,88.7 93.42,88.7 93.42,88.7 93.94,88.7 94.06,88.57 94.06,87.88 93.94,87.75 93.6,87.75 93.47,87.88 93.47,87.97 93.36,88.09 93.14,88.09 92.37,88.85 92.09,88.85 91.93,88.69 91.93,88.54 92.87,87.6 92.87,87.42 92.64,87.2 92.46,87.2 v1(91.62,88.04) 91.17,88.49 90.99,88.49 90.77,88.26 90.77,88.08 92.03,86.82 92.03,86.64 91.9,86.51 91.64,86.51 91.42,86.73 91.19,86.73 91.07,86.61 91.07,86.1 90.94,85.97 90.76,85.97 90.63,86.1 90.63,86.68 90.51,86.8 90.25,86.8 90.13,86.68 90.13,85.9 89.93,85.7 89.84,85.7 89.35,85.21
SPI_CS_CPU_N1: length 25.5
  TOP w0.114: R1828.2 96.93,90.2 v2(96.93,89.5)
  BOTTOM w0.089: CPU1.AU2 88.81,83.36 88.81,83.58 88.75,83.71 88.75,84.15 89.13,84.54 89.13,85.27 89.15,85.29
  BOTTOM w0.114: 89.15,85.29 89.93,86.07 89.93,86.72 89.68,86.96 89.47,86.96 89.19,87.24 89.19,88.12 89.3,88.23 90.08,88.23 90.6,88.76 91.48,88.76 92.05,89.33 92.37,89.33 92.98,89.94 94.41,89.94 v1(94.65,90.18) 94.93,90.46 97.98,90.46 98.65,89.79 98.65,86.53 98.53,86.4 97.54,86.4 97.42,86.53 97.42,89.02 v2(96.93,89.5)
SPI_CS_ROM_N0: length 69.6
  TOP w0.114: v2(93.15,89.48) 93.28,89.35 93.28,89.29 R1812.1 ; v2(117.25,106.14) 117.06,105.95 R2490.1 116.3,105.38 R2501.1 115.29,106.39 115.29,107.73 115.16,107.86 114.66,107.86 114.54,107.73 114.54,107.34 114.41,107.21 113.9,107.21 113.77,107.34 113.77,107.79 114.01,108.03 114.01,108.23 113.68,108.57 113.51,108.57 112.93,107.98 112.77,107.98 112.53,108.23 112.53,108.39 113.11,108.97 113.11,109.13 111.54,110.71 111.54,112.34 111.42,112.46 110.19,112.46 110.06,112.34 110.06,111.78 110.33,111.51 110.96,110.88 110.96,110.58 110.96,110.13 111.47,109.63 111.47,109.05 111.41,108.99 111.41,107.92 111.54,107.79 111.92,107.79 112.05,107.92 v2(112.05,108.17)
  L6 w0.102: v2(112.05,108.17) 112.05,108.71 111.92,108.83 110.78,108.83 110.65,108.71 110.65,103.47 107.77,100.59 103.61,100.59 100.7,97.68 99.81,97.68 97.04,94.91 96.89,94.91 96.25,95.55 96.07,95.55 95.89,95.37 95.89,95.19 96.53,94.55 96.53,94.4 96.32,94.19 96.17,94.19 95.49,94.87 95.31,94.87 95.13,94.69 95.13,94.51 95.81,93.83 95.81,93.68 95.6,93.47 95.45,93.47 94.76,94.16 94.58,94.16 94.35,93.93 94.35,93.75 94.98,93.12 94.98,91.87 94.85,91.74 94.6,91.74 94.49,91.62 94.49,91.27 94.58,91.18 94.88,91.18 95,91.05 95,90.75 94.19,89.93 93.45,89.93 93.28,89.76 93.28,89.6 v2(93.15,89.48)
  BOTTOM w0.114: SPI251.1 118.92,105.63 118.33,106.22 118.33,106.57 117.74,107.16 v1(116.34,107.16) 115.7,107.16 115.58,107.03 115.58,106.71 115.7,106.58 116.8,106.58 117.06,106.32 117.06,106.27 117.18,106.14 v2(117.25,106.14)
SPI_CS_ROM_N1: length 92.6
  TOP w0.114: R1828.1 96.68,91.92 v2(96.43,92.17) ; v2(127.67,104.87) 128.25,104.87 v1(128.66,104.46) 130.24,102.88 130.73,102.88 130.73,102.88 132.17,102.88 132.6,102.45 133.75,101.3 133.75,101.22 134.65,100.32 135.02,100.32 137.42,97.92 137.42,97.4 139.83,94.99 139.83,86.58 v2(139.96,86.45) 140.14,86.45 140.34,86.66 140.34,87.7 140.47,87.83 140.65,87.83 140.77,87.7 140.77,86.71 140.9,86.58 141.08,86.58 141.21,86.45 141.21,86.07 141.08,85.95 140.65,85.95 140.52,85.82 140.52,85.59 140.65,85.46 141.21,85.46 141.33,85.34 141.33,85.01 141.66,84.68 141.66,83.86 141.84,83.69 142.12,83.69 142.26,83.83 142.44,83.83 142.66,83.6 142.66,83.42 142.44,83.19 142.44,83.09 142.7,82.82 142.7,82.01 142.86,81.86 142.88,81.86 143.08,81.66 143.08,81.5 143,81.41 143,81.26 143.24,81.02 143.42,81.02 143.54,81.15 143.72,81.15 143.88,80.98 143.88,80.8 143.75,80.66 143.75,80.51 143.99,80.27 143.99,80.09 143.73,79.83 143.55,79.83 143.41,79.98 142.25,81.14 142.25,82.74 141.29,83.7 141.29,84.06 141.22,84.13 141.22,84.15 R2491.1
  L6 w0.102: v2(112.3,107.28) 111.72,106.7 111.72,103.03 108.21,99.52 105.51,99.52 104.05,99.52 101.14,96.61 100.26,96.61 96.43,92.78 v2(96.43,92.17)
  BOTTOM w0.114: SPI252.1 139.27,87.59 R2502.1 139.67,86.45 v2(139.96,86.45) ; v2(112.3,107.28) 112.74,107.72 117.74,107.72 119.32,106.13 121.32,106.13 121.49,105.96 123.91,105.96 125.81,104.06 126.86,104.06 v2(127.67,104.87)
SPI_HOLD_CPU: length 26.1
  TOP w0.114: R1811.2 v1(94.88,90.46) 93.83,90.46 v2(93.76,90.38)
  BOTTOM w0.089: 88.63,84.31 88.57,84.25 88.57,83.67 88.62,83.57 88.62,82.99 88.72,82.89 88.72,82.15 CPU1.AU4
  BOTTOM w0.114: 88.63,84.31 88.94,84.62 88.94,85.37 89.73,86.16 89.73,86.63 89.6,86.76 86.33,86.76 86.2,86.89 86.2,87.34 86.33,87.47 88.7,87.47 88.83,87.6 88.83,87.95 88.7,88.08 86.44,88.08 86.31,88.21 86.31,88.68 86.43,88.79 89.2,88.79 89.48,89.06 89.62,89.06 89.86,89.31 90.65,89.31 90.83,89.13 91.33,89.13 91.9,89.7 92.21,89.7 92.82,90.31 93.69,90.31 v2(93.76,90.38)
SPI_HOLD_ROM: length 38.5
  TOP w0.114: R2503.2 R2509.2 120.91,106.27 v1(120.4,105.76) 120.09,105.44 R1835.2 118.71,104.87 115.98,104.87 114.39,106.46 114.39,106.58 114.13,106.83 112.03,106.83 v2(111.6,107.26) ; R1811.1 v2(95.79,92.17)
  L6 w0.102: v2(95.79,92.17) 95.79,92.65 100.11,96.97 101,96.97 103.9,99.88 105.66,99.88 105.66,99.88 108.06,99.88 111.36,103.18 111.36,107.03 v2(111.6,107.26)
SPI_HOLD_ROM_R: length 20.4
  TOP w0.114: R2503.1 123.74,107.16 v2(124.01,107.42) 124.14,107.3 v1(124.14,106.88)
  BOTTOM w0.114: v2(124.01,107.42) 121.6,107.42 121.47,107.55 121.47,107.79 121.6,107.92 123.58,107.92 123.7,108.04 123.7,108.3 123.58,108.43 121.6,108.43 121.47,108.55 121.47,108.83 121.6,108.96 124.32,108.96 124.45,108.83 124.45,106.47 124.57,106.34 124.77,106.34 124.9,106.47 124.9,106.65 125.03,106.77 125.25,106.77 125.38,106.65 125.38,105.66 125.51,105.53 125.72,105.53 125.84,105.66 125.84,106.55 126.19,106.9 SKT251.7
SPI_SI_CPU: length 72.2
  TOP w0.114: v2(96.28,88.09) 96.21,88.09 96.02,87.9 95.61,87.9 95.6,87.92 R1826.2 R1825.1 94.46,87.72 94.46,85.9 R1824.2
  L6 w0.102: v2(96.28,88.09) 96.4,87.98 96.78,87.98 97.85,89.04 97.85,93.2 100.55,95.9 101.46,95.9 104.37,98.81 104.63,98.81 108.5,98.81 112.43,102.74 112.43,105.51 113.19,106.27 v2(113.19,106.39)
  BOTTOM w0.089: 90,83.57 90,82.49 CPU1.AV3
  BOTTOM w0.114: v2(113.19,106.39) 113.63,106.83 114.13,106.83 116.78,104.18 118.01,102.96 119.11,102.96 119.23,103.07 119.23,103.43 119.34,103.55 119.69,103.55 119.8,103.43 119.8,103.07 119.91,102.96 120.26,102.96 120.37,103.07 120.37,103.43 120.49,103.55 120.83,103.55 120.94,103.43 120.94,103.07 121.06,102.96 121.4,102.96 121.51,103.07 121.51,103.85 121.63,103.97 121.97,103.97 122.09,103.85 122.09,103.07 122.2,102.96 124.52,102.96 124.83,102.96 125.2,102.59 128.05,102.59 129.11,101.54 129.11,100.9 129.28,100.73 129.8,100.73 129.93,100.86 129.93,101.41 130.05,101.54 130.59,101.54 130.72,101.41 130.72,99.29 131.01,99 131.37,99 131.5,99.13 131.5,100.22 131.96,100.69 R1808.2 ; v2(96.28,88.09) 96.21,88.09 v1(95.25,87.14) 94.55,86.44 93.23,86.44 91.14,84.35 90.42,84.35 90,83.93 90,83.57
SPI_SI_ROM: length 6
  TOP w0.114: v2(131.53,101.34) 131.8,101.07 v1(131.8,100.62) 131.58,100.4 131.12,100.4 130.8,100.72 R2506.2
  BOTTOM w0.114: v2(131.53,101.34) 131.56,101.36 132.37,101.36 132.8,100.93 R2405.1 ; R1808.1 132.8,100.69 R2405.1 ; R2405.1 R2512.2
SPI_SI_ROM_EC: length 55.9
  TOP w0.114: v2(137.24,95.42) 137.29,95.42 139.03,93.69 v1(139.03,92.02) 139.03,86.18 139.18,86.02 139.18,85.37 139.86,84.69 139.86,83.71 141.47,82.11 141.47,80.88 148.14,74.2 148.14,73.68 155.72,66.11 155.99,66.11 160.69,61.41 161.37,61.41 163.47,59.31 R2486.1
  BOTTOM w0.114: R2405.2 132.8,97.1 134.55,95.34 136.81,95.34 136.91,95.45 137.22,95.45 v2(137.24,95.42)
SPI_SI_ROM_R: length 13.4
  TOP w0.114: R2506.1 129.18,100.93 127.98,102.13 127.3,102.13 125.21,104.22 v1(125.21,104.95) 125.21,105.38 125.44,105.62 EC2501.1 125.13,106.46 125.13,107.54 v2(125,107.66)
  BOTTOM w0.114: SKT251.5 125.51,109.44 125,108.93 v2(125,107.66)
SPI_SO_CPU: length 69
  TOP w0.114: v2(137.19,93.31) 137.76,93.31 R1807.2
  L6 w0.102: v2(96.93,88.74) 97.49,89.3 97.49,93.35 100.4,96.26 101.31,96.26 104.22,99.17 105.37,99.17 105.37,99.17 108.36,99.17 112.07,102.88 112.07,105.91 v2(112.55,106.39)
  BOTTOM w0.114: CPU1.AW3 90.61,82.89 91.06,82.89 91.23,83.06 91.23,83.51 91.43,83.7 91.43,83.95 93.05,85.57 96.04,85.57 96.93,86.47 v1(96.93,87.22) v2(96.93,88.74) ; v2(112.55,106.39) 116.73,102.22 123.84,102.22 124.21,101.85 127.11,101.85 131.48,97.49 131.48,97.38 135.54,93.31 v2(137.19,93.31)
SPI_SO_ROM: length 24.7
  TOP w0.114: R2406.1 139.38,84.65 138.69,85.34 v2(138.69,85.44) 138.56,85.57 138.56,93.4 R1807.1 136.56,95.41 v1(136.56,96.74) 136.56,97.74 134.72,99.58 134.61,99.58 134.61,99.58 134.34,99.58 133.91,100.01 132.86,101.06 132.86,101.14 131.86,102.14 131.03,102.14 130.82,102.14 R2507.1
  BOTTOM w0.114: v2(138.69,85.44) 138.3,85.83 137.85,85.83 137.73,85.94 137.73,85.94 137.62,86.05 137.62,86.06 137.28,86.39 R2513.1
SPI_SO_ROM_EC: length 34.9
  TOP w0.114: R2487.1 162.59,59.51 v1(161.63,60.47) 161.06,61.04 160.53,61.04 156.16,65.41 155.89,65.41 147.77,73.53 147.77,74.05 141.1,80.72 141.1,81.95 140.53,82.52 139.57,82.52 139.35,82.75 139.35,83.17 R2406.2
SPI_SO_ROM_R: length 14.3
  TOP w0.114: v2(127.01,104.87) 127.01,104.58 EC2502.1 127.86,103.4 127.73,103.27 127.64,103.27 127.51,103.14 127.51,102.96 127.6,102.87 128.55,102.87 v1(128.86,102.56) 129.54,101.88 R2507.2
  BOTTOM w0.114: SPI251.2 SKT251.2 121.52,106.9 121.65,106.77 121.65,106.47 121.77,106.34 122.13,106.34 122.26,106.47 122.26,106.93 122.38,107.05 122.84,107.05 122.97,106.93 122.97,106.74 123.2,106.5 123.89,106.5 125.96,104.43 126.57,104.43 v2(127.01,104.87)
SPI_WP_CPU: length 81.3
  TOP w0.114: v2(137.19,93.95) 136.75,93.51 136.75,93.13 137.02,92.87 137.13,92.87 137.88,92.12 v1(137.88,85.52) 138.68,84.72 v2(138.68,84.7) ; R1827.2 95.35,85.88 v2(95.98,86.52)
  L6 w0.102: v2(95.98,86.52) 96.93,87.47 96.93,87.62 98.2,88.9 98.2,89.19 98.2,93.05 100.7,95.55 101.61,95.55 104.51,98.46 104.78,98.46 108.65,98.46 112.78,102.59 112.78,103.16 112.78,103.16 112.78,105.23 v2(113.95,106.39)
  BOTTOM w0.089: 90.79,83.94 90.79,83.73 90.26,83.2 CPU1.AW2
  BOTTOM w0.114: 90.79,83.94 90.99,84.14 91.33,84.14 93.27,86.07 95.54,86.07 v2(95.98,86.52) ; v2(137.19,93.95) 135.43,93.95 131.85,97.53 131.85,97.64 127.27,102.22 124.45,102.22 124.08,102.59 117.75,102.59 v2(113.95,106.39) ; v2(138.68,84.7) 138.59,84.7 138.28,84.4 136.05,84.4 135.58,84.87 R1809.2
SPI_WP_ROM: length 19.5
  TOP w0.114: v2(137.07,91.79) 136.68,91.79 135.67,92.8 135.67,94.2 v1(131.31,98.56) 131.29,98.58 R2508.1
  BOTTOM w0.114: R1809.1 134.88,85.71 134.89,85.71 135.52,86.33 R2514.1 135.38,86.48 135,86.48 R1834.2 134.45,87.44 134.78,87.44 136.05,88.7 136.05,91.02 136.82,91.79 v2(137.07,91.79)
SPI_WP_ROM_R: length 18.8
  TOP w0.114: R2508.2 129.57,99.79 127.61,101.75 127.15,101.75 124.66,104.24 124.66,107.37 124.45,107.58 124.45,107.6 124.19,107.86 119.99,107.86 v1(119.62,107.49) 118.95,107.49 v2(118.78,107.66)
  BOTTOM w0.114: SKT251.3 SPI251.3 119.03,108.17 118.78,107.92 v2(118.78,107.66)
SPKR: length 178.4
  TOP w0.254: v2(90.25,81.65) 90.04,81.44 R2006.2
  L3 w0.254: v2(81.32,106.14) 83.01,106.14 83.82,106.95 84.82,106.95 85.41,106.36 85.41,105.47 89.61,101.27 89.61,99.13 87.77,97.28 87.77,93.33 88.61,92.49 88.64,92.49 90.61,90.52 90.61,89.1 90.84,88.87 90.84,86.48 89.69,85.34 89.69,82.21 v2(90.25,81.65)
  L4 w0.254: v2(26.45,36.8) 24.82,36.8 21.59,40.02 19.92,40.02 18.19,41.75 18.19,45.43 16.67,46.96 16.67,57.2 16.7,57.24 17.08,57.61 17.08,57.61 17.69,58.22 17.69,58.98 17.08,59.59 17.08,64.09 15.91,65.26 15.91,70.47 15.4,70.98 15.4,70.98 14.77,71.62 14.77,72.3 14.15,72.91 14.15,74.85 13.32,75.68 13.32,76.62 14.15,77.45 14.15,79.37 13.37,80.15 13.37,87.68 18.52,92.83 18.97,92.83 21.74,95.6 25.81,95.6 26.45,96.23 28.35,96.23 30.89,93.69 30.89,93.35 32.38,91.87 34.92,91.87 35.13,92.08 39.78,92.08 39.78,92.08 40.31,92.08 42.61,94.38 v2(43.51,94.38)
  L6 w0.254: v2(81.32,106.14) 81.32,103.02 77.2,98.9 76.87,98.9 75.34,97.38 69.87,97.38 69.39,96.91 66.66,96.91 66.4,96.65 62.81,96.65 58.93,96.65 58.83,96.74 47.32,96.74 45.4,94.82 43.96,94.82 v2(43.51,94.38)
  BOTTOM w0.254: CPU1.AW5 89.88,81.28 v2(90.25,81.65) ; RN2701.2 26.72,37.89 v1(26.47,37.64) 26.47,36.82 v2(26.45,36.8)
SPKR_MUTE_TP: length 1.7
  TOP w0.102: TP2703.1 26.05,25.51 HDA27.7
SRTC_RST#: length 32.2
  TOP w0.102: RN1801.4 107.67,88.63 106.77,87.73 106.67,87.73 v1(106.66,87.72) 106.53,87.6 105.89,87.6 EC1806.1 C1805.1 105.51,86.93 v2(104.93,86.36)
  L3 w0.102: v2(104.93,86.36) 104.93,86.35 104.93,85.69 100.72,81.48 100.61,81.48 100.18,81.05 100.18,79.17 97.06,76.05 97.06,74.15 96.41,73.5 92.74,73.5 92.39,73.85 87.29,73.85 86.84,74.3 v2(86.82,74.3)
  BOTTOM w0.102: v2(86.82,74.3) 86.82,74.16 CPU1.AN18
SUS_STAT#/LPCPD#: length 16.3
  TOP w0.102: v2(93.59,77.4) 93.59,78.14 v1(93.3,78.43) ; v2(98.08,86.96) 98.84,86.2 R1814.2
  L3 w0.102: v2(98.08,86.96) 98.08,86.23 95.79,83.95 95.79,80.22 95.59,80.02 95.59,79.3 95,78.71 94.9,78.71 v2(93.59,77.4)
  BOTTOM w0.089: v2(93.59,77.4) 93.47,77.4 93.1,77.77 92.73,77.77 92.39,77.42 91.96,77.42 91.69,77.69 CPU1.BA11
SUSACK#: length 120.3
  TOP w0.102: v1(158.32,56.99) 158.36,56.96 KBC24.34 158.36,52.65 153.61,47.9 150.2,47.9 149.44,48.66 148.52,48.66 147.73,47.87 v2(147.38,47.87) ; RN1702.2 97.99,84.37 98.86,85.24 99.67,85.24 v2(100.1,84.81)
  L3 w0.102: v2(100.1,84.81) 100.1,85.88 103.11,88.88 103.11,91.1 105.89,93.89 107.06,93.89 109.77,96.6 110.98,96.6 114.33,99.96 122.74,99.96 124.08,98.62 124.37,98.62 124.88,98.12 126.48,98.12 126.97,98.62 127.83,98.62 129.46,96.98 129.46,96.79 131.52,94.74 131.52,87.3 131.3,87.08 131.3,85.91 132.06,85.15 132.06,84.12 130.92,82.98 130.92,67.55 137.16,61.31 138.67,61.31 141.68,58.3 144.38,58.3 146.58,56.1 146.58,53.4 146.97,53 146.97,48.71 146.95,48.69 146.95,48.3 v2(147.38,47.87)
SUSACK#_R: length 13.3
  TOP w0.114: v2(86.82,77.95) 87.26,78.4 89.3,78.4 89.39,78.49 89.78,78.49 91.68,80.38 91.68,80.52 92.64,81.48 92.72,81.48 v1(93.3,82.06) 94.33,83.09 94.33,83.67 R1708.2 95.04,84.37 RN1702.3
  BOTTOM w0.114: v2(86.82,77.95) 86.82,77.82 CPU1.AP11
SUSCLK: length 136.1
  TOP w0.114: v2(94.56,72.16) 94.52,72.21 94.52,72.23 94.2,72.55 R1813.2
  L3 w0.114: v2(148.23,37.39) 148.73,37.88 149.05,37.88 151.03,39.87 151.03,42.75 151,42.78 151,43.14 151.05,43.19 151.05,45.05 151.39,45.39 151.73,45.39 152.41,46.07 v2(152.43,46.07)
  L4 w0.114: v2(152.43,46.07) 148.62,49.88 146.38,49.88 143.57,52.69 143.57,56.42 142.99,56.99 141.76,56.99 141,56.23 138.97,56.23 137.86,57.34 137.86,61.4 133.2,66.07 133.2,72.3 131.75,73.75 131.75,84.07 131.99,84.31 131.99,85.25 131.56,85.68 131.56,94.76 129.36,96.97 129.36,97.34 127.92,98.77 126.9,98.77 126.6,98.48 125.03,98.48 124.48,99.03 122.68,99.03 122.32,98.68 118.17,98.68 113.7,94.2 113.7,93.27 113.03,92.6 111.48,92.6 110.63,91.75 110.61,91.75 107.7,88.84 107.7,88.1 107.5,87.9 104.11,84.51 101.68,84.51 100.92,85.27 100.56,85.27 100.56,85.26 99.61,85.26 99.6,85.27 99.24,85.27 98.76,84.79 98.76,84.22 98.13,83.59 98.13,75.95 98.18,75.9 98.18,75.53 98.13,75.49 98.13,74.61 98.74,74.01 98.74,73.64 98.48,73.39 98.12,73.39 98.12,73.39 95.31,73.39 94.56,72.64 v2(94.56,72.16)
  BOTTOM w0.114: v2(148.23,37.39) 148.62,37.39 148.66,37.34 v1(148.8,37.34) 148.8,37.21 148.65,37.05 148.65,36.09 R2493.1
SUSCLK_R: length 5.9
  TOP w0.114: v2(93.71,74.14) 93.89,73.96 R1813.1 93.45,73.44 v1(93.01,72.99) EC1803.2
  BOTTOM w0.102: CPU1.BA17 91.78,74.07 92.06,74.35 92.37,74.35 92.54,74.18 92.54,74.03 92.78,73.78 93.36,73.78 v2(93.71,74.14)
SWCLK: length 3.4
  TOP w0.152: TP6904.1 83.6,101.57 85.76,101.57 86.14,101.95 U6901.37
SWDIO: length 3.4
  TOP w0.152: U6901.34 85.14,103.75 84.96,103.57 83.45,103.57 TP6903.1
SYS_PRES1#: length 7.6
  BOTTOM w0.102: R4301.1 98.33,24.48 AFTP4309.1 96.05,22.2 96.05,20.66
  BOTTOM w0.762: BATT1.6 96.05,20.66
SYS_PWROK: length 172.9
  TOP w0.102: v2(156.45,47.62) 154.22,45.38 151.15,45.38 150.49,44.72 146.93,44.72 146.34,44.14 146.06,44.14 145.98,44.07 KBC24.89 144,44.07 v1(142.75,45.31) ; v2(67.49,81.31) 67.34,81.46 R1717.1 66.76,81.06 EC1702.1
  L3 w0.102: v2(156.45,47.62) 156.45,49.81 156.7,50.06 156.7,53.27 v2(157.49,54.07)
  L4 w0.102: v2(157.49,54.07) 157.49,56.37 156.87,57 156.87,60.09 153.79,63.17 153.79,65.06 152.61,66.24 152.61,66.35 148.54,70.43 145.64,70.43 144.52,71.55 143.36,71.55 142.48,72.43 142.48,73.29 139.43,76.35 139,76.35 137.83,77.52 137.83,81.25 136.35,82.72 136.35,89.58 135.29,90.65 135.29,96.28 133.23,98.34 133.23,98.77 129.7,102.3 129.06,102.3 128.1,103.27 124.76,103.27 124.61,103.42 116.39,103.42 111.24,98.27 109.19,98.27 108.61,98.85 104.51,98.85 103.11,97.45 99.85,97.45 97.42,95.01 95.92,95.01 95.22,95.71 95.22,97.34 94.7,97.86 84.03,97.86 81.41,95.24 76.44,95.24 75.6,96.09 74.26,96.09 73.66,95.48 71.04,95.48 68.3,92.75 68.3,91.56 67.44,90.7 67.44,86.68 67.27,86.51 67.27,86.15 67.44,85.97 67.44,81.36 v2(67.49,81.31)
  BOTTOM w0.102: v2(67.49,81.31) 67.77,81.03 69.55,81.03 69.76,81.23 70.12,81.23 70.39,80.97 CPU1.B6
T_CRIT#: length 38.3
  TOP w0.102: R2604.2 v2(72.1,36.23) 72.1,36.66 v1(71.97,36.8) 71.61,37.16 THM261.4
  L4 w0.102: v2(102.14,30.45) 101.37,31.22 92.58,31.22 91.11,29.75 88.25,29.75 87.69,30.31 87.2,30.31 84.56,32.95 81.42,32.95 80.33,34.04 78.26,34.04 77.96,34.34 75.05,34.34 73.1,36.29 72.17,36.29 v2(72.1,36.23)
  BOTTOM w0.102: R2601.1 101.57,31.65 102.14,31.08 v2(102.14,30.45)
THERM_SYS_SHDN#: length 5
  BOTTOM w0.102: Q2602.S 99.03,29.88 v1(100.46,31.31) 100.83,31.31 R2601.2 101.31,30.7 R2602.1
THM_SML1_CLK: length 121.1
  TOP w0.114: RN2602.4 104.26,91.8 103.52,92.55 103.52,92.95 103.32,93.15 v2(103.32,93.27) 103.24,93.27 102.78,93.73 102.78,94.2 102.16,94.82 Q2601.4 ; v2(111.82,50.06) 111.4,50.47 110.96,50.47 110.46,49.97 95.01,49.97 93.45,48.41 90.27,48.41 89.69,48.99 86.27,48.99 85.5,48.23 85.5,47.06 84.87,46.43 84.87,45.05 82.96,43.15 82.96,39.06 82.5,38.6 81.77,38.6 81.16,39.2 74.08,39.2 73.61,39.68 73.61,41.96 73.02,42.55 73.02,44.51 72.36,45.16 71.8,45.16 71.74,45.22 70.43,45.22 69.29,44.08 68.8,44.08 68.5,43.78 C2608.1 68.53,43.68 THM261.8
  L4 w0.114: v2(109.81,96.03) 109.71,96.03 107,93.31 103.41,93.31 103.36,93.27 v2(103.32,93.27)
  BOTTOM w0.114: v2(109.81,96.03) v1(110.97,94.87) 111.44,94.4 111.44,90.77 113.15,89.06 113.15,82.62 112.08,81.54 112.08,50.77 111.82,50.51 v2(111.82,50.06)
THM_SML1_DATA: length 123.4
  TOP w0.114: v2(111.18,50.03) 110.78,49.62 95.15,49.62 93.59,48.07 90.13,48.07 89.55,48.65 86.41,48.65 85.85,48.09 85.85,46.92 85.16,46.23 85.16,44.86 83.31,43.01 83.31,38.92 82.64,38.26 81.63,38.26 81.35,38.53 81.35,38.53 81.02,38.86 73.94,38.86 73.27,39.53 73.27,41.82 72.68,42.41 72.68,44.36 72.22,44.82 71.66,44.82 71.6,44.88 70.58,44.88 69.31,43.62 C2609.1 69.18,43.39 THM261.7 ; v2(103.08,92.68) 103.17,92.58 103.17,92.41 103.66,91.92 103.66,91.21 103.79,91.08 RN2602.3 104.26,90.74 103.66,90.14 101.65,90.14 100.85,90.93 v1(100.85,91.55) Q2601.1
  L4 w0.114: v2(103.08,92.68) 103.15,92.75 103.46,92.75 103.53,92.81 107.13,92.81 109.72,95.4 v2(109.81,95.4)
  BOTTOM w0.114: v2(111.18,50.03) 111.18,50.79 111.54,51.15 111.54,81.49 112.81,82.76 112.81,88.92 111.04,90.69 111.04,94.16 v2(109.81,95.4)
TOUCH_PANEL_INTR#: length 160.1
  TOP w0.102: D2402.A 138.72,75.06 v1(138.53,75.25) R2429.1 138.59,76.23 v2(138.59,79.34)
  L3 w0.102: v2(66.59,93.07) 66.59,93.17 66.33,93.44 66.33,93.59 65.46,94.46 50.45,94.46 49.82,93.83 42.55,93.83 40.78,95.6 40.13,95.6 39.4,96.32 35.48,96.32 v2(34.63,97.17)
  L4 w0.102: v2(138.59,79.34) 138.34,79.6 138.34,81.57 136.76,83.15 136.76,90.26 135.93,91.09 135.93,96.46 133.76,98.63 133.76,100.05 132.79,101.02 132.79,101.4 131.47,102.72 130.2,102.72 129.57,103.35 129.57,103.53 129.32,103.78 125.61,103.78 125.41,103.98 115.4,103.98 111.62,100.2 104.03,100.2 102.22,98.38 98.67,98.38 97.87,97.58 97.87,97.32 97.62,97.07 97.26,97.07 96.07,98.26 92.42,98.26 83.86,98.26 81.25,95.65 76.61,95.65 75.76,96.49 74.09,96.49 73.49,95.89 70.14,95.89 68.32,94.07 67.6,94.07 v2(66.59,93.07) 66.5,92.98 66.5,89.09 66.33,88.91 v2(66.33,83.61)
  BOTTOM w0.102: v2(34.63,97.17) 34.63,96.96 33.99,96.32 31.34,96.32 30.41,97.25 HOMBD1.5 ; CPU1.A7 69.25,80.63 67.15,80.63 66.55,81.22 66.55,82.02 65.88,82.7 65.88,83.11 66.33,83.55 v2(66.33,83.61)
TOUCHPAD_INTR#: length 21.1
  TOP w0.102: v2(94.85,80.61) 94.59,80.87 94.59,81.83 95.4,82.64 v1(99.02,82.64) 99.2,82.64 99.97,81.88 99.97,80.92 100.19,80.7 100.19,80.69 100.83,80.05 100.85,80.05 101.38,79.52 103.46,79.52 103.75,79.82 R405.2 103.75,81.02 R410.2 103.47,81.3 D401.A 103.47,83.09 104.07,83.68 R404.2
  BOTTOM w0.102: CPU1.BA5 91.86,81.22 92.06,81.02 92.37,81.02 92.52,81.17 94.23,81.17 94.79,80.61 v2(94.85,80.61)
TP1_AY4: length 7.9
  BOTTOM w0.102: CPU1.AY4 91.08,81.77 91.43,82.13 91.74,82.13 91.88,81.99 91.88,81.97 92.1,81.76 94.8,81.76 94.82,81.77 95.4,81.77 95.8,81.37 TP610.1
TP2_BB3: length 3.6
  BOTTOM w0.102: TP611.1 95.35,82.7 CPU1.BB3
TP4_BB5: length 3.7
  BOTTOM w0.102: TP609.1 94.77,81.37 92.3,81.37 CPU1.BB5
TP5_AU5: length 9.3
  BOTTOM w0.102: TP607.1 96.04,82.14 95.94,82.04 95.18,82.04 94.82,82.39 92.09,82.39 91.88,82.61 91.88,82.66 91.71,82.83 91.46,82.83 91.29,82.66 91.29,82.41 91.07,82.19 90.21,82.19 89.87,81.85 89.79,81.85 CPU1.AU5
TP6_AT5: length 2.4
  TOP w0.102: TP608.1 87.54,80.23 88.31,80.23 v2(88.77,80.7)
  BOTTOM w0.102: CPU1.AT5 88.45,81.02 v2(88.77,80.7)
TP_EN#: length 87.2
  TOP w0.102: R2409.1 153.19,57.35 152.85,57 152.85,56.86 152.36,56.37 KBC24.49 152.36,54.5 152.79,54.07 v2(152.81,54.07)
  L3 w0.102: v2(98.41,23.18) 99.21,23.18 99.41,23.39 105.44,23.39 106.15,22.68 108.21,22.68 108.62,22.27 109.86,22.27 111.07,23.48 115.68,23.48 116.79,22.37 121.38,22.37 122.98,20.77 126.8,20.77 127.13,21.1 128.42,21.1 129.32,20.2 130.47,20.2 131.52,21.25 131.52,22.89 132.05,23.42 132.82,23.42 135.03,25.63 137.2,27.79 137.39,27.99 138.27,27.99 138.77,28.5 139.1,28.82 140.42,28.82 140.67,29.08 140.67,29.49 144.62,33.44 145.02,33.44 145.63,34.05 146.88,34.05 147.34,34.51 147.34,35.67 151.95,40.29 151.95,40.69 151.95,41.34 152,41.39 152,41.84 151.95,41.88 151.95,42.12 151.93,42.14 151.93,43.09 151.95,43.11 151.95,43.68 152.18,43.91 152.18,44.32 153.14,45.28 153.14,52.5 152.38,53.26 152.38,53.64 v2(152.81,54.07)
  BOTTOM w0.102: v2(152.81,54.07) 152.81,54.37 v1(153.09,54.65) ; R6504.1 98.63,22.95 v2(98.41,23.18)
TP_ON#_GATE: length 28.4
  BOTTOM w0.102: Q6503.G 121.79,21.53 121.25,22.07 119.29,22.07 118.57,21.35 118.57,20.09 118.27,19.78 108.74,19.78 106.08,22.45 102.29,22.45 Q6502.G 100.95,22.95 R6504.2 100.04,23.53 v1(99.68,23.89) 99.98,24.2 C6502.2
TP_PMODE_XDP_RST_R_N: length 6
  TOP w0.102: R9933.2 106.15,42.88 106.15,42.87 106.15,42.41 106.15,42.41 v1(106.15,42.29) 106.15,42.17 106.67,41.65 106.67,41.24 108.3,39.61 XDP1.46
TP_VDD: length 3.4
  TOP w0.381: v2(114.54,22.6) 114.54,21.86 115.91,20.49 R6503.1
  vias: v1(115.86,26.89) v2(115.35,25.37)
TPAN_VDD:
  vias: v1(27.72,96.74) v3(28.12,95.37)
TPCLK_C: length 4.3
  TOP w0.114: RN6502.3 108.67,25.68 v2(108.36,25.37)
  BOTTOM w0.114: AFTP6532.1 106.74,26.28 107.45,26.28 v2(108.36,25.37) 108.3,25.3 TP1.8
TPDATA_C: length 3.8
  TOP w0.114: v2(109,25.37) 109.09,25.46 109.32,25.69 RN6502.4
  BOTTOM w0.114: TP1.7 109.3,25.07 v2(109,25.37) 109,26 AFTP6533.1
U4006_CT: length 2.5
  BOTTOM w0.102: v1(66.3,84.5) 66.25,84.5 65.7,83.96 65.55,83.96 C4017.1 64.17,83.77 U4006.6
U4101_OUT: length 0.6
  BOTTOM w0.508: v2(75.36,105.43) 75.89,105.43 v1(75.91,105.4)
UART0_CTS#: length 7.7
  BOTTOM w0.089: CPU1.U4 78.03,82.23 78.03,82.95 77.81,83.17 77.65,83.17 77.48,83.34 77.48,83.59 77.51,83.67 77.51,84.1 77.32,84.3 77.32,85.84 77.21,85.95
  BOTTOM w0.114: TP2014.1 76.11,87.78 77.21,86.67 77.21,85.95
UART0_RTS#: length 9.9
  BOTTOM w0.089: CPU1.U3 78.66,82.77 78.66,83.26 78.63,83.35 78.63,83.63 78.66,83.71 78.66,83.8 78.73,83.87 78.73,85.86 78.65,85.95
  BOTTOM w0.114: TP2013.1 77.76,90.01 79.03,90.01 79.41,89.63 79.41,89.39 78.95,88.94 78.84,88.94 78.54,88.64 78.54,87.5 78.54,87.49 78.54,87.19 78.54,87.19 78.54,86.05 78.65,85.95
UART0_RXD: length 7.7
  BOTTOM w0.089: CPU1.U1 78.4,84.05 78.55,84.2 78.55,85.53 78.39,85.69
  BOTTOM w0.114: TP2011.1 76.74,89.76 77.07,89.76 78.09,88.74 78.09,86 78.39,85.69
UART0_TXD: length 4.7
  BOTTOM w0.089: 78.14,85.44 78.37,85.2 78.37,84.37 78.1,84.1 78.1,83.46 CPU1.U2
  BOTTOM w0.114: 78.14,85.44 77.63,85.95 77.63,86.96 TP2012.1
UART1_CTS#: length 5.6
  BOTTOM w0.089: CPU1.AB4 80.76,82.15 80.76,82.89 80.66,82.99 80.66,83.57 80.61,83.67 80.61,84.04 80.73,84.15 80.73,85.43 80.72,85.44
  BOTTOM w0.114: TP2017.1 80.72,86.66 80.72,85.44
UART1_RTS#: length 6.6
  BOTTOM w0.089: CPU1.AC3 81.44,82.46 81.44,84.24 81.82,84.62 81.82,85.44 81.44,85.82
  BOTTOM w0.114: TP2016.1 81.16,87.93 81.16,86.1 81.44,85.82
UART1_RXD: length 4
  BOTTOM w0.102: TP2015.1 81.74,86.91 81.74,85.95 82.06,85.62 82.06,84.6 81.72,84.25 CPU1.AC1
USB20_DN0_C: length 12.3
  L4 w0.102: USB1.2 12.9,63.54 13.39,63.05 13.96,63.05 14.45,62.55 14.45,61.36 14.13,61.04 14.13,60.42 14.35,60.21 14.68,60.21 v2(14.89,60.42)
  BOTTOM w0.102: TR3602.2 20.36,59.74 20.07,59.45 18.79,59.45 EU3602.1 18.26,59.45 17.9,59.45 17.16,60.19 15.12,60.19 v2(14.89,60.42)
USB20_DN1_C: length 12.5
  L4 w0.102: v2(15.91,42.26) 15.74,42.1 15.49,42.1 15.42,42.16 15.42,42.66 15.48,42.72 15.48,44.45 14.88,45.05 14.29,45.05 14.08,45.25 USB2.2
  BOTTOM w0.102: v2(15.91,42.26) 16.14,42.03 18.31,42.03 18.78,41.56 EU3604.1 20.07,41.56 20.34,41.29 21.11,41.29 ; TR3603.2 22.19,41.58 21.9,41.29 21.11,41.29 ; 21.11,41.29 v1(21.11,41.45)
USB20_DP0_C: length 12.2
  L4 w0.102: v2(14.89,59.78) 14.67,60.01 14.26,60.01 13.93,60.34 13.93,61.13 14.25,61.44 14.25,62.47 13.88,62.84 13.38,62.84 12.9,62.37 USB1.3
  BOTTOM w0.102: TR3602.3 20.22,59.06 20.04,59.25 17.81,59.25 17.08,59.99 16.1,59.99 EU3602.6 15.56,59.99 15.09,59.99 v2(14.89,59.78)
USB20_DP1_C: length 12.4
  L4 w0.102: USB2.3 14.08,44.65 14.27,44.84 14.79,44.84 15.27,44.36 15.27,42.8 15.22,42.75 15.22,42.08 15.41,41.89 15.64,41.89 v2(15.91,41.62)
  BOTTOM w0.102: v2(15.91,41.62) 15.97,41.56 EU3604.6 17.35,41.56 17.62,41.83 18.22,41.83 18.96,41.09 21.98,41.09 22.17,40.9 TR3603.3
USB30_RX_CPU_N1: length 114.7
  L6 w0.102: v2(22,61.67) 21.78,61.9 21.63,61.9 21.45,61.72 21.45,60.85 21.7,60.6 21.7,55.57 22.46,54.81 22.46,52.55 22.28,52.38 22.28,50.87 22.43,50.72 22.43,49.51 25.18,46.76 25.18,45.24 28.29,42.13 34.1,42.13 38.14,38.09 40.66,38.09 42.22,36.53 55.95,36.53 61.89,42.47 61.89,42.92 62.83,43.86 62.83,45.56 64.21,46.93 64.21,51.95 65.56,53.31 66.07,53.31 67.34,54.58 67.34,57.86 66.68,58.53 66.68,61.67 66.16,62.18 66.16,64.04 65.45,64.75 65.45,69.42 64.74,70.14 64.74,76.41 66.17,77.84 67.01,78.68 68.13,78.68 68.63,79.18 72,79.18 72.34,79.52 73.93,79.52 v2(74.58,78.87)
  BOTTOM w0.102: v2(74.58,78.87) 74.26,79.19 CPU1.H8 ; v2(22,61.67) 21.72,61.96 21.16,61.96 20.94,61.74 19.32,61.74 R3609.1
USB30_RX_CPU_N2: length 98.5
  L6 w0.102: v2(26.45,44.9) 26.45,44.69 26.72,44.42 26.73,44.42 28.51,42.64 34.31,42.64 38.34,38.61 40.86,38.61 42.43,37.04 55.74,37.04 60.1,41.4 60.1,41.93 62.33,44.16 62.33,45.77 63.7,47.14 63.7,52.22 66.81,55.34 66.81,57.24 66.16,57.89 66.16,61.15 64.94,62.37 64.94,69.13 64.23,69.84 64.23,76.63 65.55,77.95 65.55,78.5 65.88,78.82 66.37,78.82 66.75,79.2 66.75,79.22 67.24,79.72 71.1,79.72 71.58,80.21 72.18,80.21 72.34,80.05 73.94,80.05 v2(74.59,80.7)
  BOTTOM w0.102: v2(26.45,44.9) 26.22,45.13 26.02,45.13 24.54,43.66 20.16,43.66 R3612.1 ; CPU1.J6 74.91,80.38 v2(74.59,80.7)
USB30_RX_CPU_N3: length 143.6
  L6 w0.102: v2(142.06,44.74) 142.46,45.14 143.04,45.14 143.67,45.77 143.67,48.48 146.93,51.75 146.93,56.32 144.16,59.09 144.16,62.35 141.52,64.99 139.32,64.99 136.81,67.5 136.81,73.58 135.54,74.85 135.54,81.8 134.6,82.74 134.6,85.52 132.99,87.13 132.99,96.07 128.72,100.34 128.44,100.34 127.5,101.28 119.45,101.28 114.07,95.9 114.07,95.72 114.07,93.95 111.05,90.92 109.64,90.92 105.37,86.65 105.37,85.51 105.11,85.26 104.58,85.26 100.83,81.51 99.49,81.51 97.14,79.16 92.69,79.16 91.51,79.16 89.19,81.47 86.26,81.47 85.68,80.9 85.68,80.4 82.94,77.65 80.71,77.65 79.81,78.56 79.81,80.77 79.47,81.11 78.94,81.11 78.5,81.55 75.77,81.55 75.23,81.01 75.23,78.6 v2(74.58,77.95)
  BOTTOM w0.102: IOBD1.1 143.26,44.75 142.87,45.14 142.46,45.14 v2(142.06,44.74) ; v2(74.58,77.95) 74.91,78.28 CPU1.J10
USB30_RX_CPU_P1: length 114.8
  L6 w0.102: v2(21.96,62.36) 21.71,62.11 21.54,62.11 21.23,61.81 21.23,60.76 21.48,60.51 21.48,55.48 22.24,54.72 22.24,52.64 22.07,52.46 22.07,50.78 22.22,50.63 22.22,49.42 24.96,46.67 24.96,45.15 28.2,41.92 34.01,41.92 38.05,37.88 40.57,37.88 42.13,36.32 56.04,36.32 62.11,42.38 62.11,42.83 63.05,43.77 63.05,45.47 64.42,46.84 64.42,51.86 65.65,53.09 66.16,53.09 67.56,54.49 67.56,57.95 66.89,58.62 66.89,61.76 66.38,62.27 66.38,64.13 65.67,64.84 65.67,69.51 64.95,70.23 64.95,76.32 66.26,77.63 67.1,78.47 68.22,78.47 68.72,78.96 72.09,78.96 72.43,79.3 73.84,79.3 73.93,79.2 v2(73.93,78.87)
  BOTTOM w0.102: R3610.1 19.27,61.94 20.86,61.94 21.08,62.16 21.76,62.16 v2(21.96,62.36) ; CPU1.G8 73.61,79.19 v2(73.93,78.87)
USB30_RX_CPU_P2: length 98.4
  L6 w0.102: v2(26.45,45.56) 26.88,45.13 26.88,44.57 28.6,42.86 34.4,42.86 38.43,38.83 40.95,38.83 42.52,37.26 55.65,37.26 59.88,41.49 59.88,42.02 62.11,44.25 62.11,45.86 63.48,47.23 63.48,52.31 66.6,55.43 66.6,57.15 65.95,57.8 65.95,61.06 64.73,62.28 64.73,69.04 64.01,69.75 64.01,76.72 65.34,78.04 65.34,78.59 65.79,79.04 66.28,79.04 66.53,79.29 66.53,79.31 67.16,79.94 71.01,79.94 71.49,80.42 72.27,80.42 72.43,80.27 73.85,80.27 73.94,80.35 v2(73.94,80.7)
  BOTTOM w0.102: R3613.1 20.21,43.86 24.46,43.86 25.93,45.33 26.22,45.33 v2(26.45,45.56) ; v2(73.94,80.7) 74.26,80.38 CPU1.H6
USB30_RX_CPU_P3: length 144.5
  TOP w0.102: v1(73.29,78.29) 73.59,78.29 v2(73.93,77.95)
  L6 w0.102: v2(73.93,77.95) 74.37,77.52 74.76,77.52 75.02,77.77 75.02,78.08 75.45,78.51 75.45,80.92 75.86,81.34 78.4,81.34 78.85,80.89 78.85,80.89 79.38,80.89 79.6,80.68 79.6,78.47 80.63,77.44 83.03,77.44 85.9,80.31 85.9,80.81 86.35,81.25 89.1,81.25 91.42,78.94 92,78.94 97.22,78.94 99.58,81.3 100.92,81.3 104.67,85.05 105.2,85.05 105.58,85.42 105.58,86.56 109.73,90.71 111.14,90.71 114.29,93.86 114.29,95.81 119.54,101.06 127.41,101.06 128.35,100.12 128.63,100.12 132.77,95.98 132.77,87.04 134.39,85.43 134.39,82.65 135.33,81.71 135.33,74.77 136.6,73.5 136.6,67.41 139.23,64.78 141.43,64.78 143.95,62.26 143.95,59 146.72,56.23 146.72,51.84 143.45,48.57 143.45,45.86 142.95,45.35 142.22,45.35 v2(142.06,45.52)
  BOTTOM w0.102: v2(142.06,45.52) 142.24,45.34 142.96,45.34 143.05,45.25 IOBD1.2 ; v2(73.93,77.95) 74.26,78.28 CPU1.H10
USB30_RXDN1_C: length 10.3
  BOTTOM w0.102: R3609.2 17.37,61.94 16.69,61.94 16.67,61.96 EU3601.9 EU3601.1 15.26,61.96 15.12,62.1 14.77,62.1 14.03,61.35 14.03,59.68 13.49,59.15 12.48,59.15 11.77,59.86 11.51,59.86 11.4,59.75 USB1.5
USB30_RXDN2_C: length 8.9
  BOTTOM w0.102: R3612.2 18.49,43.68 17.98,43.68 17.6,44.06 17.33,44.06 17.19,43.93 EU3603.9 EU3603.1 16.15,43.93 16.01,44.06 15.66,44.06 15.42,43.83 15.42,43.01 14.77,42.36 13.73,42.36 13.17,41.8 12.73,41.8 12.58,41.65 USB2.5
USB30_RXDP1_C: length 10.2
  BOTTOM w0.102: R3610.2 17.82,62.14 16.77,62.14 16.48,62.43 EU3601.8 EU3601.2 15.26,62.43 15.12,62.3 14.69,62.3 13.82,61.44 13.82,59.77 13.41,59.35 12.56,59.35 11.85,60.06 11.49,60.06 11.4,60.15 USB1.6
USB30_RXDP2_C: length 9
  BOTTOM w0.102: USB2.6 12.58,42.18 12.76,42 13.09,42 13.65,42.56 14.69,42.56 15.22,43.1 15.22,43.91 15.58,44.26 16.01,44.26 16.15,44.4 EU3603.2 EU3603.8 17.22,44.4 17.35,44.26 17.69,44.26 18.07,43.88 18.49,43.88 R3613.2
USB30_TX_CPU_N1: length 113.8
  L6 w0.102: v2(67.1,75.91) 67.1,75.69 65.46,74.04 65.46,70.55 66.17,69.84 66.17,65.07 67.03,64.21 67.03,62.62 68.03,61.62 68.03,58.28 69.47,56.84 69.47,55.67 67.51,53.7 67.51,52.96 68.15,52.32 68.15,51.25 68.01,51.11 65.56,51.11 64.93,50.48 64.93,44.93 62.83,42.83 62.83,42.39 56.25,35.81 36.82,35.81 31.87,40.75 28.62,40.75 24.4,44.97 24.4,46.51 21.71,49.21 21.71,50.42 21.46,50.67 21.46,52.58 21.63,52.76 21.63,54.59 20.97,55.25 20.97,60.3 20.73,60.55 20.73,63.97 21.03,64.27 21.42,64.27 21.52,64.17 21.52,63.62 21.62,63.52 21.8,63.52 v2(22,63.72)
  BOTTOM w0.089: CPU1.C13 70.66,76.56 70.62,76.54 arc(70.57,76.51) 70.53,76.49 70.42,76.46 70.42,76.45 70.32,76.43 70.14,76.43 70.05,76.46 70.05,76.46 69.79,76.46 69.69,76.43 69.34,76.43 69.13,76.64
  BOTTOM w0.102: C3601.1 21.58,63.88 21.85,63.88 v2(22,63.72) ; 69.13,76.64 69.11,76.66 68.19,76.66 68.01,76.47 67.16,76.47 67.1,76.41 v2(67.1,75.91)
USB30_TX_CPU_N2: length 95.3
  L6 w0.102: v2(22.89,45.69) 23.15,45.69 23.32,45.51 23.32,44.68 23.59,44.41 28.19,39.81 31.11,39.81 36.06,34.87 57.54,34.87 60.61,37.94 60.61,38.84 62.91,41.14 63.74,41.14 67.15,44.55 67.15,45.59 69.5,47.95 69.5,54.2 70.5,55.2 70.5,57.14 68.97,58.67 68.97,62.01 67.98,63 67.98,67.33 67.18,68.13 67.18,70.07 67.18,70.07 67.18,70.25 66.4,71.02 66.4,73.65 67.28,74.53 67.99,74.53 68.45,74.99 68.45,76.15 v2(67.29,77.31)
  BOTTOM w0.102: v2(67.29,77.31) 67.29,77.26 67.38,77.17 69.75,77.17 CPU1.B13 ; v2(22.89,45.69) 22.77,45.56 C3603.1
USB30_TX_CPU_N3: length 146.3
  L6 w0.102: v2(142.19,46.37) 142.1,46.37 141.64,46.83 141.42,47.05 141.42,48.38 142.11,49.07 142.89,49.07 145.32,51.5 145.32,52.98 145.99,53.65 145.99,55.93 143.19,58.73 143.19,61.89 141.07,64.01 138.84,64.01 136.09,66.77 135.29,66.77 134.8,67.25 134.8,74.06 133.66,75.2 133.66,84.68 133.03,85.31 132.62,85.31 131.99,85.95 131.99,95.73 128.31,99.4 128.05,99.4 127.11,100.34 119.92,100.34 115.09,95.51 115.09,92.57 112.46,89.93 109.98,89.93 106.31,86.26 106.31,85.12 105.5,84.32 105.01,84.32 100.21,79.52 99.04,79.52 97.74,78.22 92.3,78.22 90.13,76.05 90.13,75.64 90.29,75.48 90.29,73.99 89.04,72.73 88.53,72.73 87.62,71.82 86.55,71.82 85.82,72.55 85.82,72.76 85.35,73.23 85.35,74.37 84.37,75.34 78.02,75.34 77.39,74.71 75.9,74.71 74.53,76.08 70.34,76.08 69.8,75.53 69.8,75.07 v2(70.01,74.86)
  BOTTOM w0.102: CPU1.B15 70.24,75.13 70.01,74.9 v2(70.01,74.86) ; IOBD1.4 143.06,46.25 142.91,46.4 142.91,46.56 142.78,46.69 142.51,46.69 v2(142.19,46.37)
USB30_TX_CPU_P1: length 113.9
  L6 w0.102: v2(22,64.48) 20.94,64.48 20.51,64.06 20.51,60.46 20.76,60.21 20.76,55.16 21.42,54.5 21.42,52.85 21.24,52.67 21.24,50.58 21.5,50.33 21.5,49.12 24.19,46.42 24.19,44.88 28.53,40.54 31.78,40.54 36.73,35.59 56.34,35.59 63.05,42.3 63.05,42.74 65.14,44.84 65.14,50.39 65.65,50.89 68.1,50.89 68.37,51.16 68.37,52.41 67.72,53.05 67.72,53.61 69.69,55.58 69.69,56.93 68.24,58.37 68.24,61.71 67.24,62.71 67.24,64.3 66.39,65.16 66.39,69.93 65.68,70.64 65.68,73.95 67.22,75.49 67.32,75.49 v2(67.74,75.91)
  BOTTOM w0.089: CPU1.D13 71.53,76.69 71.04,76.35 70.69,76.35 70.39,76.26 70.35,76.25 70.1,76.25 70.01,76.28 69.82,76.28 69.72,76.25 69.25,76.25 69.05,76.45 69.04,76.45
  BOTTOM w0.102: 69.04,76.45 69.04,76.45 68.28,76.45 v2(67.74,75.91) ; C3602.1 v2(22,64.48)
USB30_TX_CPU_P2: length 95.3
  L6 w0.102: v2(22.89,46.45) 23.27,46.45 23.54,46.18 23.54,44.77 23.68,44.63 28.28,40.03 31.2,40.03 36.15,35.08 57.45,35.08 60.4,38.03 60.4,38.93 62.82,41.36 63.65,41.36 66.93,44.64 66.93,45.68 69.29,48.04 69.29,54.29 70.28,55.29 70.28,57.05 68.75,58.58 68.75,61.92 67.76,62.91 67.76,67.24 66.96,68.04 66.96,70.16 66.19,70.93 66.19,73.74 67.19,74.75 67.9,74.75 68.23,75.08 68.23,76.06 67.42,76.88 66.99,76.88 v2(66.88,76.78)
  BOTTOM w0.102: C3604.1 v2(22.89,46.45) ; v2(66.88,76.78) 67.01,76.91 67.49,76.91 67.56,76.97 69.51,76.97 69.59,76.89 CPU1.A13
USB30_TX_CPU_P3: length 146.3
  L6 w0.102: v2(69.37,74.85) 69.58,75.06 69.58,75.62 70.25,76.29 73.42,76.29 74.62,76.3 75.99,74.92 77.3,74.92 77.94,75.56 84.46,75.56 85.56,74.46 85.56,73.32 86.03,72.85 86.03,72.64 86.64,72.04 87.53,72.04 88.44,72.95 88.95,72.95 90.08,74.07 90.08,75.39 89.92,75.55 89.92,76.14 92.21,78.43 97.65,78.43 98.95,79.74 100.12,79.74 104.92,84.54 105.41,84.54 106.09,85.21 106.09,86.35 109.89,90.15 112.37,90.15 114.88,92.66 114.88,95.6 119.83,100.55 127.2,100.55 128.14,99.61 128.4,99.61 132.2,95.82 132.2,86.04 132.71,85.53 133.12,85.53 133.88,84.77 133.88,75.29 135.02,74.15 135.02,67.34 135.38,66.99 136.18,66.99 138.93,64.23 141.16,64.23 143.41,61.98 143.41,58.82 146.21,56.02 146.21,53.56 145.54,52.89 145.54,51.41 142.98,48.85 142.2,48.85 141.64,48.29 141.64,47.14 141.79,46.98 142.03,46.98 v2(142.19,47.14)
  BOTTOM w0.102: v2(142.19,47.14) 142.44,46.89 142.86,46.89 143,46.75 IOBD1.5 ; v2(69.37,74.85) 69.59,75.07 CPU1.A15
USB30_TXDN1_C: length 8.7
  BOTTOM w0.102: R3605.2 17.85,63.62 16.69,63.62 16.56,63.49 EU3601.7 EU3601.4 15.26,63.49 15.12,63.62 14.71,63.62 13.11,65.22 12.6,65.22 11.89,65.92 11.83,65.98 11.56,65.98 11.5,65.92 11.5,65.92 11.4,65.82 USB1.8
USB30_TXDN1_R: length 1.9
  BOTTOM w0.102: R3605.1 19.4,63.98 20.03,63.98 C3601.2
USB30_TXDN2_C: length 8.5
  BOTTOM w0.102: R3611.2 18.49,45.84 17.96,45.84 17.73,45.61 17.38,45.61 17.22,45.45 EU3603.7 EU3603.4 16.15,45.45 16.01,45.59 15.72,45.59 14.33,46.98 13.7,46.98 12.81,47.87 12.66,47.87 12.58,47.8 USB2.8
USB30_TXDN2_R: length 1.8
  BOTTOM w0.102: C3603.2 21.03,45.84 20.19,45.84 R3611.1
USB30_TXDP1_C: length 8.4
  BOTTOM w0.102: USB1.9 11.87,66.3 11.92,66.24 12.05,66.06 12.68,65.42 13.19,65.42 14.79,63.82 15.12,63.82 15.26,63.96 EU3601.5 EU3601.6 16.56,63.96 16.69,63.82 17.34,63.82 R3606.2
USB30_TXDP1_R: length 1.8
  BOTTOM w0.102: R3606.1 19.2,64.18 20.11,64.18 C3602.2
USB30_TXDP2_C: length 8.4
  BOTTOM w0.102: USB2.9 12.58,48.18 12.68,48.08 12.89,48.08 13.78,47.19 14.41,47.19 15.81,45.79 16.01,45.79 16.15,45.93 EU3603.5 EU3603.6 17.19,45.93 17.3,45.81 17.64,45.81 17.87,46.04 18.49,46.04 R3614.2
USB30_TXDP2_R: length 1.9
  BOTTOM w0.102: C3604.2 21.3,46.41 20.94,46.04 20.19,46.04 R3614.1
USB30_VCCA: length 11.4
  TOP w0.508: USB1.1 12.9,66.41 13.97,65.35 13.97,59.18 14.63,58.51 v2(14.89,58.51)
  BOTTOM w0.508: 12.9,67.16 USB1.1 13.61,66.45 ; EU3602.5 15.41,58.77 15.15,58.51 v2(14.89,58.51)
  vias: v1(24.04,63.21)
USB30_VCCB: length 11.6
  TOP w0.508: USB2.1 15.2,47.33 15.2,40.8 15.64,40.35 v2(15.91,40.35)
  BOTTOM w0.508: 14.84,48.45 USB2.1 14.08,49.21 ; EU3604.5 16.42,40.61 16.17,40.35 v2(15.91,40.35)
  vias: v1(17.95,49.08)
USB_3+: length 8.4
  TOP w0.102: U6901.33 85.1,104.26 v2(85,104.36) 84.74,104.11 R6906.2
  BOTTOM w0.102: R6904.1 90.37,102.81 v1(87.74,102.81) 86.54,102.81 v2(85,104.36)
USB_3-: length 2.6
  TOP w0.102: U6901.32 85.21,104.75 84.97,105 R6905.2 v1(84.3,105.91)
USB_CAMERA_N: length 6.6
  TOP w0.102: 56.9,97.23 56.59,97.23 56.22,96.86 56.22,96.41 v2(55.91,96.11) ; 56.9,97.23 v1(56.9,97.38) ; 56.9,97.23 57.54,97.23 57.82,97.5 57.82,98.42 57.6,98.63 TR5501.3
  BOTTOM w0.102: v2(55.91,96.11) 56.2,95.82 56.2,94.99 56.05,94.85 LCD1.16
USB_CAMERA_P: length 6.6
  TOP w0.102: 58.02,97.5 58.02,97.42 57.63,97.03 56.67,97.03 56.42,96.77 56.42,96.36 v2(56.67,96.11) ; 58.02,97.5 v1(58.17,97.5) ; 58.02,97.5 58.02,98.42 58.28,98.68 TR5501.2
  BOTTOM w0.102: LCD1.15 56.55,94.85 56.4,94.99 56.4,95.83 v2(56.67,96.11)
USB_CHG_EN: length 176.1
  TOP w0.102: KBC24.117 154.36,40.43 155.22,41.29 155.98,41.29 v2(156.41,40.86) ; v1(20.99,52.6) v2(20.99,53.18)
  L3 w0.102: v2(156.41,40.86) 156.41,38.21 156.26,38.06 156.26,38.05 155.93,37.73 155.93,37.73 155.06,36.86 155.06,34.13 155.4,33.79 155.4,29.69 154.06,28.35 152.39,28.35 151.04,27 147.91,27 147.25,26.33 137.17,26.33 135.87,25.03 135.87,23.51 136.37,23.01 136.37,21.62 134.38,19.63 131.33,19.63 130.8,19.09 123.22,19.09 122.28,20.03 116.9,20.03 115.23,21.71 108.08,21.71 107.4,22.4 106.07,22.4 105.28,23.18 99.5,23.18 99.07,22.75 98.15,22.75 94.9,26 87.13,26 82.99,30.14 81.76,30.14 77.79,34.11 44.13,34.11 43.74,33.72 35.6,33.72 29.64,39.69 23.95,45.38 23.95,48.66 21.5,51.11 21.5,52.67 v2(20.99,53.18)
  BOTTOM w0.102: v2(20.99,53.18) 21.38,53.57 U3401.5
USB_CPU_PN0: length 108.9
  TOP w0.102: v2(81.28,79.46) 81.12,79.46 80.8,79.77 v1(80.78,79.77)
  L6 w0.102: v2(23.78,51.78) 23.41,51.42 23.41,49.62 27.62,45.41 27.62,44.86 28.9,43.58 34.7,43.58 38.73,39.55 41.25,39.55 41.95,38.86 50.1,38.86 51.34,40.1 57.44,40.1 59.16,41.83 59.16,42.32 60.45,43.61 60.45,45.22 62.76,47.53 62.76,52.66 65.87,55.77 65.87,56.77 65.21,57.42 65.21,60.72 64,61.93 64,68.71 63.29,69.42 63.29,77.02 64.61,78.34 64.61,79.76 64.97,80.12 66.27,80.12 66.85,80.7 69.52,80.7 70.4,81.58 72.78,81.58 73.48,82.28 73.9,82.28 80.28,82.28 80.86,81.69 80.86,79.75 81.15,79.46 v2(81.28,79.46)
  BOTTOM w0.102: CPU1.AB9 80.96,79.13 v2(81.28,79.46) ; v2(23.78,51.78) 23.55,52.01 23.55,52.16 23.78,52.39 U3401.2
USB_CPU_PN1: length 105
  L6 w0.102: v2(82.36,80.88) 82.19,81.06 82.19,82.28 81.46,83 73.78,83 73.18,83 72.53,82.35 70.15,82.35 70.15,82.35 67.48,82.35 65.97,80.84 63.85,80.84 62.26,79.25 62.26,77.17 62.57,76.87 62.57,65.75 63.28,65.04 63.28,61.63 64.47,60.44 64.47,55.42 62.02,52.97 62.02,47.82 60.41,46.21 59.86,46.21 59.09,45.43 59.09,43.29 58.44,42.64 58.44,42.14 57.12,40.82 51.01,40.82 49.96,39.77 42.18,39.77 37.54,44.42 30.39,44.42 30,44.8 29.55,44.8 29.25,44.5 v2(28.65,44.5)
  BOTTOM w0.102: v2(28.65,44.5) 28.65,43.88 28.5,43.73 27.41,43.73 26.39,42.72 ; CPU1.AD6 82.04,80.88 v2(82.36,80.88) ; TR3603.1 24.15,41.58 24.42,41.32 25.65,41.32 25.94,41.61 25.94,42.27 26.39,42.72 ; v1(26.29,42.83) 26.39,42.72
USB_CPU_PN2: length 119
  TOP w0.102: TR6601.2 155.4,62.33 155.4,63.26 v2(155.02,63.64)
  L6 w0.102: v2(83.25,84.73) 83.76,84.73 83.94,84.92 83.94,86.39 84.94,87.39 85.61,87.39 87.59,85.41 91.51,85.41 92.88,84.04 98.12,84.04 99.6,85.53 100.49,85.53 102.74,87.77 102.74,89.4 104.28,90.94 105.64,90.94 108.37,93.67 108.38,93.67 109.46,94.75 110.15,94.75 118.64,103.23 119.06,103.23 119.06,103.23 128.31,103.23 129.25,102.29 129.61,102.29 135.21,96.7 135.21,89.62 135.95,88.88 135.95,87 136.56,86.4 136.56,83.73 137.64,82.64 137.64,76.32 139.66,74.3 139.66,74.29 141.61,72.34 142.04,72.34 143.63,70.75 144.9,70.75 148.28,67.37 148.28,66.58 149.5,65.36 150.51,65.36 151.16,64.71 155.25,64.71 155.58,64.38 155.58,64.21 v2(155.02,63.64)
  BOTTOM w0.089: 83.99,84.48 83.99,84.46 83.99,84.45 83.96,84.28 83.96,83.71 83.9,83.58 83.9,83.43 83.92,83.39 83.97,83.25 83.97,83.06 83.9,82.93 83.9,82.78 83.92,82.74 83.92,82.73 83.97,82.6 83.97,82.6 84,82.53 84.35,82.19 CPU1.AH3
  BOTTOM w0.102: 83.99,84.48 84,84.58 84,84.97 83.81,85.17 83.68,85.17 v2(83.25,84.73) ; v1(155.38,64.18) 155.02,63.82 v2(155.02,63.64)
USB_CPU_PN2_C: length 20.8
  TOP w0.102: TR6601.1 155.27,60.33 v2(155.07,60.13)
  BOTTOM w0.102: IOBD1.8 144.41,48.25 144.7,47.95 144.92,47.95 146.87,49.9 148.73,49.9 150.37,51.55 150.37,54.03 152.99,56.65 154.16,56.65 154.63,57.13 ; 154.63,57.13 v1(154.51,57.24) ; 154.63,57.13 155.4,57.9 155.4,60.03 155.3,60.13 v2(155.07,60.13)
USB_CPU_PN3: length 30.2
  TOP w0.102: R6905.1 82.84,105 82.71,104.87 v2(82.71,104.87) ; v2(82.36,78.91) 82.23,78.91 v1(81.9,79.24)
  L3 w0.102: v2(82.71,104.87) 83.09,104.87 83.37,104.59 83.37,103.12 82.15,101.9 82.15,92.31 82.73,91.74 82.73,90.34 81.88,89.49 81.88,86.72 82.53,86.06 82.53,82.92 82.25,82.64 82.25,81.38 81.93,81.06 81.93,80.5 81.93,80.5 81.93,79.76 81.93,79.75 81.93,79.34 v2(82.36,78.91)
  BOTTOM w0.102: CPU1.AD9 82.13,79.13 v2(82.36,78.91)
USB_CPU_PN4: length 53.9
  TOP w0.102: TR5501.4 57.86,100.42 57.86,101.14 v2(57.69,101.31)
  L3 w0.102: v2(85.59,100.3) 85.78,100.1 85.78,99.51 83.95,97.68 83.95,94.88 84.92,93.91 84.92,92.51 83.95,91.54 83.95,90.11 84.34,89.73 84.34,87.4 84.33,87.4 84.33,86.13 84.63,85.83 84.63,85.49 v2(85.11,85.01)
  BOTTOM w0.102: v2(85.11,85.01) 85.35,85.31 85.43,85.39 85.62,85.39 85.88,85.13 85.88,84.46 85.23,83.81 CPU1.AJ1 ; 58.18,100.43 57.97,100.64 57.97,101.03 v2(57.69,101.31) ; 58.18,100.43 58.44,100.17 59.86,100.17 60.09,100.4 62.32,100.4 62.85,100.93 64.51,100.93 66.04,99.4 69.71,99.4 70.26,98.85 75.75,98.85 76.44,99.54 81.19,99.54 82.89,101.24 85.58,101.24 86,100.82 86,100.71 v2(85.59,100.3) ; 58.18,100.43 v1(58.02,100.27)
USB_CPU_PN5: length 108.7
  TOP w0.102: v2(150.91,63.48) 150.65,63.22 150.65,62.29 R6605.2
  L6 w0.102: v2(83.39,81.4) 83.61,81.62 83.61,81.9 84.73,83.02 88.24,83.02 88.25,83.02 90.9,83.02 91.45,82.47 98.4,82.47 98.89,82.96 100.16,82.96 101.76,84.56 101.76,85.58 104.6,88.43 104.6,89.18 108.58,93.16 108.69,93.16 109.77,94.24 110.37,94.24 118.85,102.72 128.1,102.72 129.04,101.78 129.36,101.78 134.65,96.49 134.65,96.31 134.65,89.43 135.43,88.65 135.43,86.81 136.05,86.18 136.05,83.51 137.07,82.49 137.07,76.17 139.15,74.09 139.15,74.05 141.38,71.81 141.73,71.81 143.31,70.24 144.69,70.24 147.69,67.24 147.69,66.44 149.32,64.82 150.34,64.82 150.91,64.25 v2(150.91,63.48)
  BOTTOM w0.102: v2(150.91,63.48) 150.91,62.92 v1(150.84,62.85) ; CPU1.AF6 83.18,81.09 83.39,81.3 v2(83.39,81.4)
USB_CPU_PN5_C: length 16.1
  TOP w0.102: v2(150.96,60.13) 150.68,60.41 150.68,60.86 R6605.1
  BOTTOM w0.102: 150.1,56.07 150.86,56.82 150.86,60.03 v2(150.96,60.13) ; 150.1,56.07 149.16,55.12 149.16,52.06 148.22,51.12 146.56,51.12 146.29,50.84 144.8,50.84 144.71,50.75 IOBD1.13 ; 150.1,56.07 v1(150.25,55.92)
USB_CPU_PN6: length 80.5
  TOP w0.102: R5510.2 31.17,102.08 31.78,102.08 v2(31.91,102.2)
  L3 w0.102: v2(83.27,86.68) 83.03,86.91 82.65,86.91 82.39,87.18 82.39,89.28 83.24,90.13 83.24,91.95 82.66,92.52 82.66,95.29 83.24,95.87 83.24,100.83 83.83,101.42 84.31,101.42 84.72,101 84.72,100.47 v2(84.9,100.3)
  BOTTOM w0.102: 43.47,102.66 36.84,102.66 36.25,102.08 32.04,102.08 v2(31.91,102.2) ; 43.47,102.66 v1(43.47,102.84) ; 43.47,102.66 48.25,102.66 51.86,99.05 60.17,99.05 61.01,99.89 61.77,99.89 64.39,99.89 65.39,98.9 69.13,98.9 69.76,98.27 76.06,98.27 76.82,99.03 80.81,99.03 81.48,99.03 83.18,100.73 84.47,100.73 v2(84.9,100.3) ; CPU1.AH1 84.49,83.61 84.49,85.46 v2(83.27,86.68)
USB_CPU_PN7: length 113.6
  TOP w0.102: TR6602.2 152.73,62.75 152.99,63.01 152.99,63.35 v2(152.72,63.62)
  L6 w0.102: v2(152.72,63.62) 153.14,63.2 153.14,63.14 153.14,62.96 153.02,62.83 149.38,62.83 149.03,63.19 149.03,64.09 146.97,66.14 146.97,66.94 144.39,69.51 142.25,69.51 141.6,70.16 141.35,70.16 138.42,73.08 138.42,73.79 136.35,75.87 136.35,77.22 136.35,77.22 136.35,82.1 135.33,83.12 135.33,85.88 133.75,87.46 133.75,96.17 133.75,96.35 129.04,101.06 129.01,101.06 128.74,101.06 127.8,102 119.15,102 113.14,95.99 113.14,95.14 110.44,92.44 108.88,92.44 105.33,88.88 105.33,88.01 103.99,86.67 103.9,86.67 103.52,86.29 103.52,86.21 102.48,85.16 102.48,84.26 100.46,82.24 99.19,82.24 98.67,81.72 91.18,81.72 90.6,82.3 88.55,82.3 88.54,82.3 85.81,82.3 84.69,81.17 84.69,80.54 83.94,79.8 83.7,79.8 83.57,79.93 83.57,79.93 83.47,80.03 v2(83.47,80.13)
  BOTTOM w0.102: v2(83.47,80.13) 83.07,80.13 82.9,79.97 CPU1.AF8 ; v1(152.23,63.89) 152.46,63.89 v2(152.72,63.62)
USB_CPU_PN7_C: length 17.8
  TOP w0.102: v2(152.58,60.13) 152.73,60.28 TR6602.1
  BOTTOM w0.102: v2(152.58,60.13) 152.7,60.13 152.9,59.92 152.9,58.63 152.09,57.82 ; 152.09,57.82 151.77,57.5 151.77,56.44 149.66,54.33 149.66,51.84 148.43,50.62 146.58,50.62 145.48,49.52 144.91,49.52 144.69,49.75 IOBD1.11 ; 152.09,57.82 v1(151.95,57.96)
USB_CPU_PP0: length 109.3
  TOP w0.102: v2(23.15,51.78) 23.15,52.04 v1(23.43,52.32)
  L6 w0.102: v2(81.28,78.78) 80.85,79.22 80.85,79.46 80.65,79.66 80.65,81.6 80.19,82.06 73.99,82.06 73.56,82.06 72.87,81.36 70.49,81.36 69.61,80.49 66.94,80.49 66.36,79.9 65.06,79.9 64.83,79.68 64.83,78.25 63.51,76.93 63.51,69.51 64.22,68.8 64.22,62.02 65.42,60.81 65.42,57.51 66.08,56.86 66.08,55.68 62.97,52.57 62.97,47.44 60.66,45.13 60.66,43.52 59.38,42.23 59.38,41.74 57.52,39.88 51.43,39.88 50.18,38.64 41.86,38.64 41.16,39.34 38.64,39.34 34.61,43.36 28.81,43.36 27.4,44.77 27.4,45.32 26.32,46.41 26.32,46.41 26.23,46.5 23.2,49.53 23.2,51.73 v2(23.15,51.78)
  BOTTOM w0.102: v2(23.15,51.78) 23.28,51.92 U3401.3 ; v2(81.28,78.78) CPU1.AB10
USB_CPU_PP1: length 105
  L6 w0.102: v2(29.12,44.06) 29.64,44.58 29.91,44.58 30.3,44.2 37.45,44.2 42.09,39.55 50.05,39.55 51.1,40.61 57.21,40.61 58.65,42.05 58.65,42.55 59.3,43.2 59.3,45.35 59.95,45.99 60.5,45.99 62.24,47.73 62.24,52.88 64.69,55.33 64.69,60.53 63.49,61.72 63.49,65.13 62.78,65.84 62.78,76.96 62.48,77.26 62.48,79.16 63.94,80.63 66.06,80.63 67.57,82.14 70.24,82.14 70.24,82.14 72.62,82.14 73.27,82.78 73.69,82.78 81.37,82.78 81.97,82.19 81.97,81.1 81.93,81.06 81.93,80.68 v2(82.37,80.25)
  BOTTOM w0.102: v2(82.37,80.25) 82.02,80.25 CPU1.AD7 ; 27.85,43.53 v1(27.85,43.38) ; 27.85,43.53 28.58,43.53 v2(29.12,44.06) ; 27.85,43.53 27.49,43.53 26.14,42.18 26.14,41.52 25.74,41.12 24.36,41.12 24.15,40.9 23.65,40.9 TR3603.4

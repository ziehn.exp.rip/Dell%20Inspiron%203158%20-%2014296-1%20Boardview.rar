# Allegro board 14296-1.0727WZS1940.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C144KA-108A7-L-1
  round 1.422 hole 1.016: 1(7,0) 2(5,0) 3(3,0) 4(1,0) 5(-1,0) 6(-3,0) 7(-5,0) 8(-7,0)
  oval 1.422x3.404 hole 0.711x2.692: 9(10.125,0) 10(-10.125,0)
C402H20
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
C402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
C603
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H36
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H40
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C805H54
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
C805H56
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
C805H58
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
C1206H71
  rect 1.854x1.27 smd: 1(0,1.397) 2(0,-1.397)
CON2O-U
  custom 0.159x0.159 smd: 1(0,0.254) 2(0,-0.254)
CT3528H79
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT7343H83
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
CT7343H119
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
D5436AKH98
  rect 2.286x2.032 smd: A(0,2.438) K(0,-2.438)
DFN8F3-G2416-1H32
  rect 0.406x0.991 smd: 1(0.975,1.513) 2(0.325,1.513) 3(-0.325,1.513) 4(-0.975,1.513) 5(-0.975,-1.513) 6(-0.325,-1.513) 7(0.325,-1.513) 8(0.975,-1.513)
  rect 2.388x1.6 smd: 9(0,0)
DFN8F3-G2517H32
  rect 0.406x0.94 smd: 1(0.975,1.538) 2(0.325,1.538) 3(-0.325,1.538) 4(-0.975,1.538) 5(-0.975,-1.538)
  rect 0.025x0.025 smd: 6(-0.325,-1.538) 8(0.975,-1.538)
  custom 0.235x0.235 smd: 7(0.325,-1.538)
  rect 2.489x1.676 smd: 9(0,0)
DFN8G2-G1710-U1H32
  rect 0.305x0.686 smd: 1(0.75,1.106) 2(0.25,1.106) 3(-0.25,1.106) 4(-0.75,1.106) 5(-0.75,-1.106) 6(-0.25,-1.106) 7(0.25,-1.106) 8(0.75,-1.106)
  rect 1.702x0.94 smd: 9(0,0)
DFN10G2510H26
  rect 0.305x0.787 smd: 1(1,0.494) 5(-1,0.494) 6(-1,-0.494) 10(1,-0.494)
  rect 0.254x0.787 smd: 2(0.521,0.494) 4(-0.521,0.494) 7(-0.521,-0.494) 9(0.521,-0.494)
  rect 0.025x0.025 smd: 3(0,0.494)
  rect 0.406x1.753 smd: 8(0,-0.494)
DFN14J3020-G255D85H32
  custom 0.151x0.151 smd: 1(1.2,1.076) 6(-0.8,1.076) 8(-1.2,-1.076) 13(0.8,-1.076)
  rect 0.025x0.025 smd: 2(0.8,1.076) 7(-1.2,1.076) 9(-0.8,-1.076) 14(1.2,-1.076)
  rect 0.203x0.864 smd: 3(0.4,1.076) 4(0,1.076) 5(-0.4,1.076) 10(-0.4,-1.076) 11(0,-1.076) 12(0.4,-1.076)
  rect 2.54x0.838 smd: 15(0,0)
DM-HS81100-01
  rect 0.813x1.6 smd: 1(-5.625,2.9) 2(-4.375,2.9) 3(-3.125,2.9) 4(-1.875,2.9) 5(-0.625,2.9) 6(0.625,2.9) 7(1.875,2.9) 8(3.125,2.9) 9(4.375,2.9) 10(5.625,2.9)
  rect 2.108x2.997 smd: 11(-8.175,0) 12(8.175,0)
DS2RK-20401-TP4B-U
  round 0.254 hole 1.118 unplated: (-33.4,0)
  round 0.254 hole 1.6 unplated: (33.4,0)
  custom 0.114x0.114 smd: 1(31.65,4.1) 2(31.35,-4.1) 3(31.05,4.1) 4(30.751,-4.1) 5(30.45,4.1) 6(30.15,-4.1) 7(29.85,4.1) 8(29.55,-4.1) 9(29.251,4.1) 10(28.95,-4.1) 11(28.65,4.1) 12(28.35,-4.1) 13(28.051,4.1) 14(27.751,-4.1) 15(27.45,4.1) 16(27.15,-4.1) 17(26.851,4.1) 18(26.551,-4.1) 19(26.25,4.1) 20(25.95,-4.1) 21(25.65,4.1) 22(25.35,-4.1) 23(25.051,4.1) 24(24.75,-4.1) 25(24.45,4.1) 26(24.15,-4.1) 27(23.851,4.1) 28(23.55,-4.1) 29(23.25,4.1) 30(22.95,-4.1) 31(22.651,4.1) 32(22.351,-4.1) 33(22.05,4.1) 34(21.75,-4.1) 35(21.451,4.1) 36(21.151,-4.1) 37(20.85,4.1) 38(20.55,-4.1) 39(20.25,4.1) 40(19.95,-4.1) 41(19.65,4.1) 42(19.35,-4.1) 43(19.049,4.1) 44(18.749,-4.1) 45(18.45,4.1) 46(18.15,-4.1) 47(17.85,4.1) 48(17.549,-4.1) 49(17.25,4.1) 50(16.95,-4.1) 51(16.65,4.1) 52(16.349,-4.1) 53(16.049,4.1) 54(15.75,-4.1) 55(15.45,4.1) 56(15.15,-4.1) 57(14.849,4.1) 58(14.549,-4.1) 59(14.25,4.1) 60(13.95,-4.1) 61(13.649,4.1) 62(13.349,-4.1) 63(13.05,4.1) 64(12.75,-4.1) 65(12.45,4.1) 66(12.149,-4.1) 67(11.85,4.1) 68(11.55,-4.1) 69(11.25,4.1) 70(10.95,-4.1) 71(10.649,4.1) 72(10.349,-4.1) 73(7.65,4.1) 74(7.35,-4.1) 75(7.049,4.1) 76(6.749,-4.1) 77(6.45,4.1) 78(6.15,-4.1) 79(5.85,4.1) 80(5.549,-4.1) 81(5.25,4.1) 82(4.95,-4.1) 83(4.65,4.1) 84(4.349,-4.1) 85(4.05,4.1) 86(3.75,-4.1) 87(3.45,4.1) 88(3.15,-4.1) 89(2.849,4.1) 90(2.549,-4.1) 91(2.25,4.1) 92(1.95,-4.1) 93(1.649,4.1) 94(1.349,-4.1) 95(1.05,4.1) 96(0.75,-4.1) 97(0.45,4.1) 98(0.149,-4.1) 99(-0.15,4.1) 100(-0.45,-4.1) 101(-0.75,4.1) 102(-1.051,-4.1) 103(-1.351,4.1) 104(-1.65,-4.1) 105(-1.95,4.1) 106(-2.25,-4.1) 107(-2.551,4.1) 108(-2.851,-4.1) 109(-3.15,4.1) 110(-3.45,-4.1) 111(-3.751,4.1) 112(-4.051,-4.1) 113(-4.35,4.1) 114(-4.65,-4.1) 115(-4.95,4.1) 116(-5.251,-4.1) 117(-5.55,4.1) 118(-5.85,-4.1) 119(-6.15,4.1) 120(-6.451,-4.1) 121(-6.751,4.1) 122(-7.051,-4.1) 123(-7.35,4.1) 124(-7.65,-4.1) 125(-7.951,4.1) 126(-8.251,-4.1) 127(-8.55,4.1) 128(-8.85,-4.1) 129(-9.15,4.1) 130(-9.451,-4.1) 131(-9.75,4.1) 132(-10.05,-4.1) 133(-10.35,4.1) 134(-10.651,-4.1) 135(-10.95,4.1) 136(-11.25,-4.1) 137(-11.55,4.1) 138(-11.85,-4.1) 139(-12.151,4.1) 140(-12.451,-4.1) 141(-12.75,4.1) 142(-13.05,-4.1) 143(-13.351,4.1) 144(-13.651,-4.1) 145(-13.95,4.1) 146(-14.25,-4.1) 147(-14.55,4.1) 148(-14.851,-4.1) 149(-15.15,4.1) 150(-15.45,-4.1) 151(-15.75,4.1) 152(-16.051,-4.1) 153(-16.35,4.1) 154(-16.65,-4.1) 155(-16.95,4.1) 156(-17.25,-4.1) 157(-17.551,4.1) 158(-17.851,-4.1) 159(-18.15,4.1) 160(-18.45,-4.1) 161(-18.751,4.1) 162(-19.051,-4.1) 163(-19.35,4.1) 164(-19.65,-4.1) 165(-19.95,4.1) 166(-20.251,-4.1) 167(-20.55,4.1) 168(-20.85,-4.1) 169(-21.15,4.1) 170(-21.451,-4.1) 171(-21.751,4.1) 172(-22.051,-4.1) 173(-22.35,4.1) 174(-22.65,-4.1) 175(-22.951,4.1) 176(-23.251,-4.1) 177(-23.55,4.1) 178(-23.85,-4.1) 179(-24.151,4.1) 180(-24.451,-4.1) 181(-24.75,4.1) 182(-25.05,-4.1) 183(-25.35,4.1) 184(-25.651,-4.1) 185(-25.95,4.1) 186(-26.25,-4.1) 187(-26.55,4.1) 188(-26.851,-4.1) 189(-27.151,4.1) 190(-27.451,-4.1) 191(-27.75,4.1) 192(-28.05,-4.1) 193(-28.351,4.1) 194(-28.651,-4.1) 195(-28.95,4.1) 196(-29.25,-4.1) 197(-29.55,4.1) 198(-29.851,-4.1) 199(-30.15,4.1) 200(-30.45,-4.1) 201(-30.75,4.1) 202(-31.05,-4.1) 203(-31.349,4.1) 204(-31.649,-4.1)
  rect 3.505x4.597 smd: 205(32.8,12) 206(-32.8,12)
G6179HT0321-001
  rect 0.635x2.108 smd: 1(1.905,3.466) 2(0.635,3.466) 3(-0.635,3.466) 4(-1.905,3.466) 5(-1.905,-3.466) 6(-0.635,-3.466) 7(0.635,-3.466) 8(1.905,-3.466)
GAP-CLOSE-PWR
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GS12201-1011-9H
  round 0.254 hole 0.965 unplated: (-5.8,0) (5.8,0)
  rect 0.305x1.143 smd: 1(4.75,-2.325) 2(4.25,-2.325) 3(3.75,-2.325) 4(3.25,-2.325) 5(2.75,-2.325) 6(2.25,-2.325) 7(1.75,-2.325) 8(1.25,-2.325) 9(0.75,-2.325) 10(0.25,-2.325) 11(-0.25,-2.325) 12(-0.75,-2.325) 13(-1.25,-2.325) 14(-1.75,-2.325) 15(-2.25,-2.325) 16(-2.75,-2.325) 17(-3.25,-2.325) 18(-3.75,-2.325) 19(-4.25,-2.325) 20(-4.75,-2.325)
  rect 1.295x1.397 smd: 21(5.8,1.8) 22(5.8,-2.2) 23(-5.8,1.8) 24(-5.8,-2.2)
HOLE335R178
  round 8.509 hole 4.521: 1(0,0)
HOLE335R229
  round 8.509 hole 5.817: 1(0,0)
L4240-D815-UH79
  rect 2.007x1.956 smd: 1(0,1.872) 2(0,-1.872)
L4947-1115H119
  rect 2.007x2.261 smd: 1(0,2.049) 2(0,-2.049)
L6965-1530H158
  rect 3.505x2.642 smd: 1(0,2.87) 2(0,-2.87)
L7066-1830-UH119
  rect 3.505x2.921 smd: 1(0,2.78) 2(0,-2.78)
L125100-4P-4H37
  rect 0.762x0.432 smd: 1(-0.625,0.341) 2(0.625,0.341) 3(0.625,-0.341) 4(-0.625,-0.341)
L686647-127318H119
  rect 3.683x2.413 smd: 1(0,2.986) 2(0,-2.986)
L11510030H158
  rect 3.251x3.454 smd: 1(0,4.928) 2(0,-4.928)
LFDFN8G2-G1309H40
  rect 0.305x0.483 smd: 1(0.75,0.911) 2(0.25,0.911) 3(-0.25,0.911) 4(-0.75,0.911) 5(-0.75,-0.911) 6(-0.25,-0.911) 7(0.25,-0.911) 8(0.75,-0.911)
  rect 1.295x0.889 smd: 9(0,0)
LFQFN48J6-G4D6H40
  rect 0.203x0.686 smd: 1(2.2,2.857) 2(1.8,2.857) 3(1.4,2.857) 4(1,2.857) 5(0.6,2.857) 6(0.2,2.857) 7(-0.2,2.857) 8(-0.6,2.857) 9(-1,2.857) 10(-1.4,2.857) 11(-1.8,2.857) 12(-2.2,2.857) 25(-2.2,-2.857) 26(-1.8,-2.857) 27(-1.4,-2.857) 28(-1,-2.857) 29(-0.6,-2.857) 30(-0.2,-2.857) 31(0.2,-2.857) 32(0.6,-2.857) 33(1,-2.857) 34(1.4,-2.857) 35(1.8,-2.857) 36(2.2,-2.857)
  rect 0.686x0.203 smd: 13(-2.857,2.2) 14(-2.857,1.8) 15(-2.857,1.4) 16(-2.857,1) 17(-2.857,0.6) 18(-2.857,0.2) 19(-2.857,-0.2) 20(-2.857,-0.6) 21(-2.857,-1) 22(-2.857,-1.4) 23(-2.857,-1.8) 24(-2.857,-2.2) 37(2.857,-2.2) 38(2.857,-1.8) 39(2.857,-1.4) 40(2.857,-1) 41(2.857,-0.6) 42(2.857,-0.2) 43(2.857,0.2) 44(2.857,0.6) 45(2.857,1) 46(2.857,1.4) 47(2.857,1.8) 48(2.857,2.2)
  rect 4.597x4.597 smd: 49(0,0)
LGA9G2310H13
  rect 0.305x0.381 smd: 1(1,0.31) 5(-1,0.31) 6(-1,-0.31) 9(1,-0.31)
  rect 0.254x0.381 smd: 2(0.526,0.31) 4(-0.526,0.31) 7(-0.526,-0.31) 8(0.526,-0.31)
  rect 0.406x0.991 smd: 3(0,0)
LGA12G2H40
  rect 0.381x0.381 smd: 1(0.809,0.809) 4(-0.809,0.809) 7(-0.809,-0.809) 10(0.809,-0.809)
  rect 0.305x0.432 smd: 2(0.25,0.784) 3(-0.25,0.784) 8(-0.25,-0.784) 9(0.25,-0.784)
  rect 0.432x0.305 smd: 5(-0.784,0.25) 6(-0.784,-0.25) 11(0.784,-0.25) 12(0.784,0.25)
MSOP8-1H44
  rect 0.356x1.524 smd: 1(-0.975,-2.055) 2(-0.325,-2.055) 3(0.325,-2.055) 4(0.975,-2.055) 5(0.975,2.055) 6(0.325,2.055) 7(-0.325,2.055) 8(-0.975,2.055)
MSOP10-G2D5H44
  rect 0.305x1.372 smd: 1(-1,-2.146) 2(-0.5,-2.146) 3(0,-2.146) 4(0.5,-2.146) 5(1,-2.146) 6(1,2.146) 7(0.5,2.146) 8(0,2.146) 9(-0.5,2.146) 10(-1,2.146)
  rect 2.489x2.489 smd: 11(0,0)
NTC-402H24-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
NTC-603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
PAD-60P
  round 0.254 hole 1.016 unplated: (-10.066,2.67) (10.066,2.67)
  rect 0.305x2.515 smd: 1(-7.25,-2.99) 2(-7.25,2.99) 3(-6.75,-2.99) 4(-6.75,2.99) 5(-6.25,-2.99) 6(-6.25,2.99) 7(-5.751,-2.99) 8(-5.751,2.99) 9(-5.25,-2.99) 10(-5.25,2.99) 11(-4.75,-2.99) 12(-4.75,2.99) 13(-4.249,-2.99) 14(-4.249,2.99) 15(-3.75,-2.99) 16(-3.75,2.99) 17(-3.25,-2.99) 18(-3.25,2.99) 19(-2.75,-2.99) 20(-2.75,2.99) 21(-2.25,-2.99) 22(-2.25,2.99) 23(-1.75,-2.99) 24(-1.75,2.99) 25(-1.25,-2.99) 26(-1.25,2.99) 27(-0.751,-2.99) 28(-0.751,2.99) 29(-0.25,-2.99) 30(-0.25,2.99) 31(0.25,-2.99) 32(0.25,2.99) 33(0.751,-2.99) 34(0.751,2.99) 35(1.25,-2.99) 36(1.25,2.99) 37(1.75,-2.99) 38(1.75,2.99) 39(2.25,-2.99) 40(2.25,2.99) 41(2.75,-2.99) 42(2.75,2.99) 43(3.25,-2.99) 44(3.25,2.99) 45(3.75,-2.99) 46(3.75,2.99) 47(4.249,-2.99) 48(4.249,2.99) 49(4.75,-2.99) 50(4.75,2.99) 51(5.25,-2.99) 52(5.25,2.99) 53(5.751,-2.99) 54(5.751,2.99) 55(6.25,-2.99) 56(6.25,2.99) 57(6.75,-2.99) 58(6.75,2.99) 59(7.25,-2.99) 60(7.25,2.99)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
POLYSW-2114H30
  rect 1.6x0.965 smd: 1(0,0.94) 2(0,-0.94)
POLYSW-2114H50
  rect 1.6x0.965 smd: 1(0,0.94) 2(0,-0.94)
POLYSW-4633-UH43
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-8P-2H45
  rect 0.406x1.168 smd: 1(-0.975,-2.351) 2(-0.325,-2.351) 3(0.325,-2.351) 4(0.975,-2.351)
  rect 3.404x2.769 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(1.029,0.902) 7(0.013,0.902) 8(-0.991,0.902)
PPAK-8P-G5324H44-COLAY
  rect 0.762x1.016 smd: 1(-1.905,-3.01) 2(-0.635,-3.01) 3(0.635,-3.01) 4(1.905,-3.01) 5(1.905,3.01) 6(0.635,3.01) 7(-0.635,3.01) 8(-1.905,3.01)
  rect 5.207x2.896 smd: 9(0,0.65)
  rect 5.207x0.787 smd: 10(0,-1.7)
QFN10M3-G4P-UH34
  rect 0.61x0.254 smd: 1(1.346,1.125) 2(1.346,0.675) 3(1.346,0.225) 4(1.346,-0.225) 5(1.346,-0.675) 6(1.346,-1.125)
  rect 0.254x1.168 smd: 7(0.66,-1.067)
  rect 1.981x0.914 smd: 8(-0.66,-0.94)
  custom 0.483x0.483 smd: 9(-0.432,0.051)
  rect 1.143x0.813 smd: 10(-0.241,0.991)
QFN16-G1D8-UH32
  rect 0.305x0.914 smd: 1(0.75,1.551) 2(0.25,1.551) 3(-0.25,1.551) 4(-0.75,1.551) 9(-0.75,-1.551) 10(-0.25,-1.551) 11(0.25,-1.551) 12(0.75,-1.551)
  rect 0.914x0.305 smd: 5(-1.551,0.75) 6(-1.551,0.25) 7(-1.551,-0.25) 8(-1.551,-0.75) 13(1.551,-0.75) 14(1.551,-0.25) 15(1.551,0.25) 16(1.551,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN28-G2D7H32
  rect 0.203x0.94 smd: 1(1.2,2.032) 2(0.8,2.032) 3(0.4,2.032) 4(0,2.032) 5(-0.4,2.032) 6(-0.8,2.032) 7(-1.2,2.032) 15(-1.2,-2.032) 16(-0.8,-2.032) 17(-0.4,-2.032) 18(0,-2.032) 19(0.4,-2.032) 20(0.8,-2.032) 21(1.2,-2.032)
  rect 0.94x0.203 smd: 8(-2.032,1.2) 9(-2.032,0.8) 10(-2.032,0.4) 11(-2.032,0) 12(-2.032,-0.4) 13(-2.032,-0.8) 14(-2.032,-1.2) 22(2.032,-1.2) 23(2.032,-0.8) 24(2.032,-0.4) 25(2.032,0) 26(2.032,0.4) 27(2.032,0.8) 28(2.032,1.2)
  rect 2.692x2.692 smd: 29(0,0)
QFN36J4060-G2554H40
  rect 0.203x0.559 smd: 1(1,2.873) 2(0.6,2.873) 3(0.2,2.873) 4(-0.2,2.873) 5(-0.6,2.873) 6(-1,2.873)
  rect 0.61x0.203 smd: 7(-1.848,2.2) 8(-1.848,1.8) 9(-1.848,1.4) 10(-1.848,1) 25(1.848,-2.2) 26(1.848,-1.8) 27(1.848,-1.4) 28(1.848,-1) 29(1.848,-0.6) 30(1.848,-0.2) 31(1.848,0.2) 32(1.848,0.6) 33(1.848,1) 34(1.848,1.4) 35(1.848,1.8) 36(1.848,2.2)
  rect 0.559x0.203 smd: 11(-1.848,0.6) 12(-1.848,0.2) 13(-1.848,-0.2) 14(-1.848,-0.6) 15(-1.848,-1) 16(-1.848,-1.4) 17(-1.848,-1.8) 18(-1.848,-2.2)
  rect 0.025x0.025 smd: 19(-1,-2.848) 20(-0.6,-2.848) 21(-0.2,-2.848) 22(0.2,-2.848) 23(0.6,-2.848) 24(1,-2.848)
  custom 0.665x0.665 smd: 37(0,0)
QFN40J5-G3D65H32
  rect 0.203x0.94 smd: 1(1.8,2.538) 10(-1.8,2.538) 21(-1.8,-2.538) 30(1.8,-2.538)
  rect 0.203x0.965 smd: 2(1.4,2.526) 3(1,2.526) 4(0.6,2.526) 5(0.2,2.526) 6(-0.2,2.526) 7(-0.6,2.526) 8(-1,2.526) 9(-1.4,2.526) 22(-1.4,-2.526) 23(-1,-2.526) 24(-0.6,-2.526) 25(-0.2,-2.526) 26(0.2,-2.526) 27(0.6,-2.526) 28(1,-2.526) 29(1.4,-2.526)
  rect 0.94x0.203 smd: 11(-2.538,1.8) 20(-2.538,-1.8) 31(2.538,-1.8) 40(2.538,1.8)
  rect 0.965x0.203 smd: 12(-2.526,1.4) 13(-2.526,1) 14(-2.526,0.6) 15(-2.526,0.2) 16(-2.526,-0.2) 17(-2.526,-0.6) 18(-2.526,-1) 19(-2.526,-1.4) 32(2.526,-1.4) 33(2.526,-1) 34(2.526,-0.6) 35(2.526,-0.2) 36(2.526,0.2) 37(2.526,0.6) 38(2.526,1) 39(2.526,1.4)
  rect 3.658x3.658 smd: 41(0,0)
QFN42J5-G3D6H36
  rect 0.203x0.838 smd: 1(2,2.513) 11(-2,2.513) 22(-2,-2.513) 32(2,-2.513)
  rect 0.203x0.991 smd: 2(1.6,2.513) 3(1.2,2.513) 4(0.8,2.513) 5(0.4,2.513) 6(0,2.513) 7(-0.4,2.513) 8(-0.8,2.513) 9(-1.2,2.513) 10(-1.6,2.513) 23(-1.6,-2.513) 24(-1.2,-2.513) 25(-0.8,-2.513) 26(-0.4,-2.513) 27(0,-2.513) 28(0.4,-2.513) 29(0.8,-2.513) 30(1.2,-2.513) 31(1.6,-2.513)
  rect 0.838x0.203 smd: 12(-2.513,1.8) 21(-2.513,-1.8) 33(2.513,-1.8) 42(2.513,1.8)
  rect 0.991x0.203 smd: 13(-2.513,1.4) 14(-2.513,1) 15(-2.513,0.6) 16(-2.513,0.2) 17(-2.513,-0.2) 18(-2.513,-0.6) 19(-2.513,-1) 20(-2.513,-1.4) 34(2.513,-1.4) 35(2.513,-1) 36(2.513,-0.6) 37(2.513,-0.2) 38(2.513,0.2) 39(2.513,0.6) 40(2.513,1) 41(2.513,1.4)
  rect 3.607x3.607 smd: 43(0,0)
QFN48G7-G5D7H26
  rect 0.305x0.914 smd: 1(2.75,3.551) 12(-2.75,3.551) 25(-2.75,-3.551) 36(2.75,-3.551)
  rect 0.305x0.94 smd: 2(2.25,3.538) 3(1.75,3.538) 4(1.25,3.538) 5(0.75,3.538) 6(0.25,3.538) 7(-0.25,3.538) 8(-0.75,3.538) 9(-1.25,3.538) 10(-1.75,3.538) 11(-2.25,3.538) 26(-2.25,-3.538) 27(-1.75,-3.538) 28(-1.25,-3.538) 29(-0.75,-3.538) 30(-0.25,-3.538) 31(0.25,-3.538) 32(0.75,-3.538) 33(1.25,-3.538) 34(1.75,-3.538) 35(2.25,-3.538)
  rect 0.914x0.305 smd: 13(-3.551,2.75) 24(-3.551,-2.75) 37(3.551,-2.75) 48(3.551,2.75)
  rect 0.94x0.305 smd: 14(-3.538,2.25) 15(-3.538,1.75) 16(-3.538,1.25) 17(-3.538,0.75) 18(-3.538,0.25) 19(-3.538,-0.25) 20(-3.538,-0.75) 21(-3.538,-1.25) 22(-3.538,-1.75) 23(-3.538,-2.25) 38(3.538,-2.25) 39(3.538,-1.75) 40(3.538,-1.25) 41(3.538,-0.75) 42(3.538,-0.25) 43(3.538,0.25) 44(3.538,0.75) 45(3.538,1.25) 46(3.538,1.75) 47(3.538,2.25)
  rect 5.69x5.69 smd: 49(0,0)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H15
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R805H24
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
R1206H26
  rect 1.854x1.27 smd: 1(0,1.397) 2(0,-1.397)
R1206H28
  rect 1.854x1.27 smd: 1(0,1.397) 2(0,-1.397)
R2512H32
  rect 3.505x1.778 smd: 1(0,2.794) 2(0,-2.794)
R3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SKT-HDMI23-178125-1
  oval 0.762x0.914 hole 0.508: 1(-4.5,6.08) 2(-4,7.58) 3(-3.5,6.08) 4(-3,7.58) 5(-2.5,6.08) 6(-2,7.58) 7(-1.5,6.08) 8(-1,7.58) 9(-0.5,6.08) 10(0,7.58) 11(0.5,6.08) 12(1,7.58) 13(1.5,6.08) 14(2,7.58) 15(2.5,6.08) 16(3,7.58) 17(3.5,6.08) 18(4,7.58) 19(4.5,6.08)
  oval 1.524x3.023 hole 0.813x2.362: 20(-7.25,6.98) 21(7.25,6.98)
  rect 1.549x2.388 smd: 22(-8.625,0) 23(8.625,0)
SKT-USB13-158172-1
  round 1.168 hole 0.813: 1(3.5,10.9) 2(1,10.9) 3(-1,10.9) 4(-3.5,10.9) 5(-4,9.4) 6(-2,9.4) 7(0,9.4) 8(2,9.4) 9(4,9.4)
  oval 1.422x2.972 hole 0.711x2.413: 10(6.4,10.15) 11(-6.4,10.15)
  oval 1.422x1.93 hole 0.711x1.219: 12(-7.75,0) 13(7.75,0)
SKT-USB14-160155-U
  round 1.067 hole 0.711: 1(3.5,9.1) 2(1,9.1) 3(-1,9.1) 4(-2.8,9.1) 5(-4,7.6) 6(-2,7.6) 7(0,7.6) 8(2,7.6) 9(4,7.6) D1(-4.6,9.1)
  oval 1.422x2.718 hole 0.711x2.007: 11(6.4,8.2) 12(-6.4,8.2)
  oval 1.422x3.327 hole 0.711x2.616: 13(7.85,0) 14(-7.85,0)
SMD49-3215-0713H36
  rect 1.549x1.549 smd: 1(0,1.371) 2(0,-1.371)
SMD49-6914-0403H56
  rect 1.168x0.559 smd: 1(-3.38,-0.427) 2(3.38,-0.427) 3(3.38,0.427) 4(-3.38,0.427)
SMD-ARES4H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMD-ARES4H20
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMPC4665-3P-UH48
  rect 1.626x1.854 smd: 1(1.066,0) 2(-1.066,0)
  rect 4.572x5.359 smd: 3(0,3.909)
SOD123FLAKH40
  rect 1.143x1.651 smd: A(0,1.622) K(0,-1.622)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH40
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH44
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD882-10D6-1H20
  custom 0.114x0.114 smd: 1(0,0.445) 2(0,-0.445)
SOD-523-4H28
  rect 0.559x0.864 smd: 1(0,0.778) 2(0,-0.778)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8-G3530H63
  rect 0.635x1.651 smd: 1(-1.905,-2.555) 2(-0.635,-2.555) 3(0.635,-2.555) 4(1.905,-2.555) 5(1.905,2.555) 6(0.635,2.555) 7(-0.635,2.555) 8(-1.905,2.555)
  rect 3.505x2.997 smd: 9(0,0)
SON5Z3025H18
  rect 0.33x0.33 smd: 1(-0.923,-0.503) 4(0.713,-0.503)
  rect 0.406x0.711 smd: 2(-0.924,0.31)
  custom 0.229x0.229 smd: 3(0.417,0.254)
  rect 0.254x2.489 smd: 5(1.375,0)
SOT23-2D4-312H44
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D8-123H52
  custom 0.254x0.254 smd: 1(0,1.118) 2(-1.016,-1.118) 3(1.016,-1.118)
SOT23-2D8-312H56
  custom 0.254x0.254 smd: 1(-1.016,-1.118) 2(1.016,-1.118) 3(0,1.118)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23CBE2D6H46
  custom 0.165x0.165 smd: B(-0.95,-1.092) C(0,1.092) E(0.95,-1.092)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D8H56
  custom 0.254x0.254 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT-6H58
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-23-5H51
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-5H52
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-5H56
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-23-10H44
  rect 0.762x1.143 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT-23-13H46
  rect 0.66x1.321 smd: 1(-0.999,-0.978) 2(0.999,-0.978) 3(0,0.978)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SPR7837H229
  rect 7.493x3.353 smd: 1(-2.095,0)
STF237R128H42
  round 6.02 hole 3.251: 1(0,0)
TPAD14-OP
  round 0.356 smd: 1(0,0)
TQFP128-2H48
  rect 0.203x1.524 smd: 1(6.2,7.747) 2(5.8,7.747) 3(5.4,7.747) 4(5,7.747) 5(4.6,7.747) 6(4.2,7.747) 7(3.8,7.747) 8(3.4,7.747) 9(3,7.747) 10(2.6,7.747) 11(2.2,7.747) 12(1.8,7.747) 13(1.4,7.747) 14(0.999,7.747) 15(0.599,7.747) 16(0.199,7.747) 17(-0.199,7.747) 18(-0.599,7.747) 19(-0.999,7.747) 20(-1.4,7.747) 21(-1.8,7.747) 22(-2.2,7.747) 23(-2.6,7.747) 24(-3,7.747) 25(-3.4,7.747) 26(-3.8,7.747) 27(-4.2,7.747) 28(-4.6,7.747) 29(-5,7.747) 30(-5.4,7.747) 31(-5.8,7.747) 32(-6.2,7.747) 65(-6.2,-7.747) 66(-5.8,-7.747) 67(-5.4,-7.747) 68(-5,-7.747) 69(-4.6,-7.747) 70(-4.2,-7.747) 71(-3.8,-7.747) 72(-3.4,-7.747) 73(-3,-7.747) 74(-2.6,-7.747) 75(-2.2,-7.747) 76(-1.8,-7.747) 77(-1.4,-7.747) 78(-0.999,-7.747) 79(-0.599,-7.747) 80(-0.199,-7.747) 81(0.199,-7.747) 82(0.599,-7.747) 83(0.999,-7.747) 84(1.4,-7.747) 85(1.8,-7.747) 86(2.2,-7.747) 87(2.6,-7.747) 88(3,-7.747) 89(3.4,-7.747) 90(3.8,-7.747) 91(4.2,-7.747) 92(4.6,-7.747) 93(5,-7.747) 94(5.4,-7.747) 95(5.8,-7.747) 96(6.2,-7.747)
  rect 1.524x0.203 smd: 33(-7.747,6.2) 34(-7.747,5.8) 35(-7.747,5.4) 36(-7.747,5) 37(-7.747,4.6) 38(-7.747,4.2) 39(-7.747,3.8) 40(-7.747,3.4) 41(-7.747,3) 42(-7.747,2.6) 43(-7.747,2.2) 44(-7.747,1.8) 45(-7.747,1.4) 46(-7.747,0.999) 47(-7.747,0.599) 48(-7.747,0.199) 49(-7.747,-0.199) 50(-7.747,-0.599) 51(-7.747,-0.999) 52(-7.747,-1.4) 53(-7.747,-1.8) 54(-7.747,-2.2) 55(-7.747,-2.6) 56(-7.747,-3) 57(-7.747,-3.4) 58(-7.747,-3.8) 59(-7.747,-4.2) 60(-7.747,-4.6) 61(-7.747,-5) 62(-7.747,-5.4) 63(-7.747,-5.8) 64(-7.747,-6.2) 97(7.747,-6.2) 98(7.747,-5.8) 99(7.747,-5.4) 100(7.747,-5) 101(7.747,-4.6) 102(7.747,-4.2) 103(7.747,-3.8) 104(7.747,-3.4) 105(7.747,-3) 106(7.747,-2.6) 107(7.747,-2.2) 108(7.747,-1.8) 109(7.747,-1.4) 110(7.747,-0.999) 111(7.747,-0.599) 112(7.747,-0.199) 113(7.747,0.199) 114(7.747,0.599) 115(7.747,0.999) 116(7.747,1.4) 117(7.747,1.8) 118(7.747,2.2) 119(7.747,2.6) 120(7.747,3) 121(7.747,3.4) 122(7.747,3.8) 123(7.747,4.2) 124(7.747,4.6) 125(7.747,5) 126(7.747,5.4) 127(7.747,5.8) 128(7.747,6.2)
unnamed#2
  round 0.254 hole 2.184 unplated: (0,0)

## Nets
1.8V_RUN_FB: PC5305.2 PR5303.2 PR5304.1 PU5301.2
3V5V_CT1: C4001.1 U4001.12
3V5V_CT2: C4002.1 U4001.10
3V5V_S0_ON: R4010.2 U4001.3 U4001.5
3V_5V_EN: C4009.1 D4001.1 PR4521.2 PR4527.2 R4006.1 R4009.1
3V_5V_POK: C1710.1 EC1705.1 PR4519.2 PR4522.2 PR5217.1 PR5307.1 PU4503.7 R1718.2 R1728.2 R4033.1
3V_5V_POK#: Q1701.5 Q1701.6 R1726.1
3V_5V_POK_C: Q1701.2 R1727.2 R1728.1 R1729.1
5V_AUX_S5: PG4534.2 R2726.1 R2915.1
5V_HDMI_R_S5: F5701.1 R5715.2 R5716.2
5V_HDMI_S5: C5713.1 F5701.2 HDMI1.18
5V_S0: C2706.1 C2708.1 C2709.1 C2711.1 C2722.1 C4005.1 C6002.1 C6004.1 D5701.3 EC8916.1 EC8917.1 F5501.1 F6501.1 HDA27.13 HDA27.16 HDD1.8 HDD1.9 HDD1.10 HDD1.11 R2612.1 R2722.1 R5507.1 R5716.1 R6501.1 R6510.1 U4001.13 U4001.14
5V_S5: C1718.1 C3402.1 C3502.1 C4031.1 C4032.1 EC8914.1 EC8915.1 IOBD1.46 IOBD1.47 IOBD1.48 IOBD1.49 IOBD1.50 PC4520.1 PC4707.1 PC4807.1 PC5001.1 PC5301.1 PG4531.1 PG4532.1 PL4501.2 PR4303.1 PR4657.1 PR4671.1 PR4702.2 PR4803.2 PR5117.2 PT4501.1 PU4701.7 PU4701.36 PU4803.3 PU4803.7 PU4803.36 PU5002.4 PU5301.6 Q6505.E R3402.1 R3405.1 R3406.1 R5715.1 U1702.3 U3401.1 U3501.5 U4001.1 U4001.2 U4001.4 U4002.4 U4006.4
+1.8V: C4027.1 Q4006.D R2725.1
+3VLP: KBC24.120 R2454.1 R2463.2
+5V_KB_BL: AFTP6529.1 C6501.1 F6501.2 KBLIT1.1 R6501.2
+V1.00A_SIP: C1108.1 C2101.1 C2104.1 C2116.1 C2121.1 CPU1.A10 CPU1.A14 CPU1.AB17 CPU1.AB19 CPU1.AB20 CPU1.AK20 CPU1.K17 CPU1.L1 CPU1.L21 CPU1.P18 CPU1.T1 CPU1.Y18 R1117.2 R1803.2 R2108.1 R2109.1 R2110.1 R2111.1
+V1.00A_XDP: C9902.1 C9904.1 R9927.2 R9932.1
+V1.00U_CPU: C4012.1 R2492.1 R4036.1 R4038.1 U4006.7 U4006.8
+V1.8A: C4022.1 C4026.1 PC5302.1 PC5304.1 PC5305.1 PR5303.1 PU5301.3 PU5301.4 Q4006.S R1139.2 R4044.1
+V1.8A_SIP: C1106.1 C2108.1 CPU1.AA1 CPU1.AF16 R1139.1
+V3.3A_SIP: C1104.1 C1183.1 C2105.1 C2106.1 C2107.1 C2109.1 C2110.1 C2111.1 CPU1.AD15 CPU1.AG15 CPU1.AJ16 CPU1.AJ21 CPU1.AK15 CPU1.AK17 CPU1.T16 CPU1.V19 CPU1.Y15 CPU1.Y16 R1110.2 R1701.1 R1731.1 R2101.1
+VCCAMPHYPLL_1P0: C2113.1 CPU1.K15 CPU1.L15 R2107.2
+VCCAPLL_1P0: C2114.1 CPU1.V15 R2108.2
+VCCCLK2: C2115.1 CPU1.K19 R2109.2
+VCCCLK4: C2119.1 CPU1.N20 R2110.2
+VCCCLK5: C2122.1 CPU1.L19 R2111.2
+VCCCOREG0: CPU1.K32 TP701.1
+VCCCOREG1: CPU1.AK32 TP707.1
+VCCDSW_1P0: C2103.1 CPU1.AL1
+VCCFUSEPRG: CPU1.G20 R703.1
+VCCGT: C1136.1 C1138.1 C1147.1 C1148.1 C1149.1 C1150.1 CPU1.A48 CPU1.A53 CPU1.A58 CPU1.A62 CPU1.A66 CPU1.AA63 CPU1.AA64 CPU1.AA66 CPU1.AA67 CPU1.AA69 CPU1.AA70 CPU1.AA71 CPU1.AC64 CPU1.AC65 CPU1.AC66 CPU1.AC67 CPU1.AC68 CPU1.AC69 CPU1.AC70 CPU1.AC71 CPU1.J43 CPU1.J45 CPU1.J46 CPU1.J48 CPU1.J50 CPU1.J52 CPU1.J53 CPU1.J55 CPU1.J56 CPU1.J58 CPU1.J60 CPU1.K48 CPU1.K50 CPU1.K52 CPU1.K53 CPU1.K55 CPU1.K56 CPU1.K58 CPU1.K60 CPU1.L62 CPU1.L63 CPU1.L64 CPU1.L65 CPU1.L66 CPU1.L67 CPU1.L68 CPU1.L69 CPU1.L70 CPU1.L71 CPU1.M62 CPU1.N63 CPU1.N64 CPU1.N66 CPU1.N67 CPU1.N69 CPU1.N70 CPU1.N71 CPU1.R63 CPU1.R64 CPU1.R65 CPU1.R66 CPU1.R67 CPU1.R68 CPU1.R69 CPU1.R70 CPU1.R71 CPU1.T62 CPU1.U65 CPU1.U68 CPU1.U71 CPU1.W63 CPU1.W64 CPU1.W65 CPU1.W66 CPU1.W67 CPU1.W68 CPU1.W69 CPU1.W70 CPU1.W71 CPU1.Y62 EC1006.1 EC1007.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PG4809.2 PL4801.2 PT4801.1 PT4802.1 R721.1
+VCCIO: C1151.1 C1152.1 C1153.1 C1154.1 C4007.1 CPU1.AK28 CPU1.AK30 CPU1.AL30 CPU1.AL42 CPU1.AM28 CPU1.AM30 CPU1.AM42 PC1035.1 PC1036.1 PC1037.1 R801.1 R4042.1 R9906.1 U4002.5 U4002.6 U4002.7 U4002.8
+VCCMPHYGTAON_1P0_LS_SIP: C1172.1 C1173.1 C1174.1 C1175.1 C1176.1 C1180.1 C1182.1 C1184.1 C1704.1 CPU1.AF20 CPU1.AF21 CPU1.N15 CPU1.N16 CPU1.N17 CPU1.N18 CPU1.P15 CPU1.P16 CPU1.T19 CPU1.T20 R1734.2 R2107.1
+VCCPAZIO: CPU1.AJ19 R2101.2 R2102.2
+VCCPDSW_3P3: CPU1.AD17 CPU1.AD18 CPU1.AJ17 R1703.1 R1707.1 R1711.2 R1723.1
+VCCPRTC_3P3: C2117.1 C2118.1 CPU1.AK19 CPU1.BB14 R2106.2
+VCCSA: CPU1.AK23 CPU1.AK25 CPU1.G23 CPU1.G25 CPU1.G27 CPU1.G28 CPU1.J22 CPU1.J23 CPU1.J27 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K30 EC1004.1 EC1005.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1097.1 PC1098.1 PG5001.2 PL5001.2 R735.1
+VCCSFR: C720.1 C721.1 CPU1.K20 CPU1.K21 R4038.2
+VCCST_CPU: C716.1 CPU1.A18 PC4610.1 PR4621.1 PR4622.1 PR4623.2 R419.1 R603.2 R723.1 R726.1 R727.1 R4036.2
+VCCSTG: C717.1 C4008.1 CPU1.A22 PR4624.1 R401.1 R408.2 R409.2 R416.2 R417.2 R421.2 R422.2 R423.2 R703.2 R1722.1 R2440.1 R4042.2
+VDD18: C2712.1 C2726.1 C2727.1 C2728.1 HDA27.18 HDA27.38 R2725.2 R2916.1
+VDDQ_CPU_CLK: C715.1 CPU1.AM40 R705.2
AV1_TP: CPU1.AV1 TP2307.1
AV71_TP: CPU1.AV71 TP2304.1
AVDD5V: C2713.1 HDA27.29 R2722.2 R2726.2
GND: AFTP2604.1 AFTP4301.1 AFTP4302.1 AFTP4313.1 AFTP4314.1 AFTP4315.1 AFTP6526.1 AFTP6527.1 BATT1.7 BATT1.8 BATT1.9 BATT1.10 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C1101.2 C1102.2 C1103.2 C1104.2 C1106.2 C1108.2 C1116.2 C1117.2 C1136.2 C1138.2 C1147.2 C1148.2 C1149.2 C1150.2 C1151.2 C1152.2 C1153.2 C1154.2 C1172.2 C1173.2 C1174.2 C1175.2 C1176.2 C1180.2 C1182.2 C1183.2 C1184.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1218.2 C1220.2 C1221.2 C1222.2 C1701.2 C1702.2 C1704.2 C1710.2 C1711.2 C1717.2 C1718.2 C1719.2 C1801.1 C1802.1 C1803.1 C1804.1 C1805.2 C1806.2 C2101.2 C2102.2 C2103.2 C2104.2 C2105.2 C2106.2 C2107.2 C2108.2 C2109.2 C2110.2 C2111.2 C2112.2 C2113.2 C2114.2 C2115.2 C2116.2 C2117.2 C2118.2 C2119.2 C2120.2 C2121.2 C2122.2 C2402.2 C2403.2 C2405.2 C2406.2 C2409.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2415.2 C2416.2 C2417.2 C2418.2 C2419.2 C2420.2 C2421.2 C2423.2 C2424.1 C2425.1 C2426.2 C2428.2 C2429.2 C2501.2 C2502.2 C2503.2 C2504.2 C2505.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2608.2 C2609.2 C2610.2 C2701.1 C2706.2 C2707.2 C2708.2 C2709.2 C2710.2 C2711.2 C2712.2 C2713.2 C2714.2 C2721.2 C2722.2 C2723.1 C2724.1 C2725.1 C2726.2 C2727.2 C2728.2 C2901.2 C3401.2 C3402.2 C3403.2 C3404.2 C3502.2 C3507.2 C3508.2 C3512.2 C3513.2 C4001.2 C4002.2 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4012.2 C4013.2 C4014.2 C4015.2 C4016.2 C4017.2 C4026.2 C4027.2 C4031.2 C4032.2 C4033.2 C4034.2 C4101.2 C4102.2 C5502.2 C5503.2 C5505.2 C5507.2 C5508.1 C5512.2 C5513.2 C5514.2 C5515.2 C5516.2 C5517.2 C5701.1 C5702.1 C5703.1 C5704.1 C5705.1 C5706.1 C5713.2 C5716.1 C6002.2 C6004.2 C6501.2 C6503.2 C6901.2 C6902.2 C6903.2 C6904.2 C6905.2 C6906.2 C6907.2 C6908.2 C6909.2 C7001.2 C7002.2 C7003.2 C7004.2 C7006.2 C7007.2 C9901.2 C9902.2 C9903.2 C9904.2 C9905.2 CPU1.AA2 CPU1.AA4 CPU1.AA65 CPU1.AA68 CPU1.AB8 CPU1.AB15 CPU1.AB16 CPU1.AB18 CPU1.AB21 CPU1.AD8 CPU1.AD13 CPU1.AD16 CPU1.AD19 CPU1.AD20 CPU1.AD21 CPU1.AD62 CPU1.AE64 CPU1.AE65 CPU1.AE66 CPU1.AE67 CPU1.AE68 CPU1.AE69 CPU1.AF1 CPU1.AF2 CPU1.AF4 CPU1.AF10 CPU1.AF15 CPU1.AF17 CPU1.AF63 CPU1.AG16 CPU1.AG17 CPU1.AG18 CPU1.AG19 CPU1.AG20 CPU1.AG21 CPU1.AG71 CPU1.AH6 CPU1.AH13 CPU1.AH63 CPU1.AH64 CPU1.AH67 CPU1.AJ4 CPU1.AJ15 CPU1.AJ18 CPU1.AJ20 CPU1.AK8 CPU1.AK11 CPU1.AK16 CPU1.AK18 CPU1.AK21 CPU1.AK22 CPU1.AK27 CPU1.AK63 CPU1.AK68 CPU1.AK69 CPU1.AL2 CPU1.AL4 CPU1.AL28 CPU1.AL32 CPU1.AL35 CPU1.AL38 CPU1.AL45 CPU1.AL48 CPU1.AL52 CPU1.AL55 CPU1.AL58 CPU1.AL64 CPU1.AL65 CPU1.AL66 CPU1.AM8 CPU1.AM13 CPU1.AM21 CPU1.AM25 CPU1.AM27 CPU1.AM43 CPU1.AM45 CPU1.AM46 CPU1.AM55 CPU1.AM60 CPU1.AM61 CPU1.AM68 CPU1.AM71 CPU1.AN20 CPU1.AN23 CPU1.AN28 CPU1.AN30 CPU1.AN32 CPU1.AN33 CPU1.AN35 CPU1.AN37 CPU1.AN38 CPU1.AN40 CPU1.AN42 CPU1.AN43 CPU1.AN58 CPU1.AN63 CPU1.AP10 CPU1.AP18 CPU1.AP20 CPU1.AP23 CPU1.AP28 CPU1.AP32 CPU1.AP35 CPU1.AP38 CPU1.AP42 CPU1.AP58 CPU1.AP63 CPU1.AP68 CPU1.AP70 CPU1.AR5 CPU1.AR8 CPU1.AR11 CPU1.AR15 CPU1.AR16 CPU1.AR20 CPU1.AR23 CPU1.AR28 CPU1.AR35 CPU1.AR42 CPU1.AR43 CPU1.AR45 CPU1.AR46 CPU1.AR48 CPU1.AR50 CPU1.AR52 CPU1.AR53 CPU1.AR55 CPU1.AR58 CPU1.AR63 CPU1.AT2 CPU1.AT4 CPU1.AT20 CPU1.AT23 CPU1.AT28 CPU1.AT35 CPU1.AT42 CPU1.AT56 CPU1.AT58 CPU1.AT63 CPU1.AT68 CPU1.AT71 CPU1.AU10 CPU1.AU15 CPU1.AU20 CPU1.AU32 CPU1.AU38 CPU1.AV68 CPU1.AV69 CPU1.AV70 CPU1.AW6 CPU1.AW8 CPU1.AW10 CPU1.AW12 CPU1.AW14 CPU1.AW16 CPU1.AW18 CPU1.AW21 CPU1.AW23 CPU1.AW26 CPU1.AW28 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AW38 CPU1.AW41 CPU1.AW43 CPU1.AW45 CPU1.AW47 CPU1.AW49 CPU1.AW50 CPU1.AW51 CPU1.AW53 CPU1.AW55 CPU1.AW57 CPU1.AW60 CPU1.AW62 CPU1.AW64 CPU1.AW66 CPU1.AY66 CPU1.B10 CPU1.B14 CPU1.B18 CPU1.B22 CPU1.B30 CPU1.B34 CPU1.B39 CPU1.B44 CPU1.B48 CPU1.B53 CPU1.B58 CPU1.B62 CPU1.B66 CPU1.BA6 CPU1.BA10 CPU1.BA14 CPU1.BA18 CPU1.BA23 CPU1.BA28 CPU1.BA32 CPU1.BA36 CPU1.BA41 CPU1.BA45 CPU1.BA49 CPU1.BA53 CPU1.BA57 CPU1.BA62 CPU1.BA66 CPU1.BB6 CPU1.BB18 CPU1.BB26 CPU1.BB30 CPU1.BB34 CPU1.BB38 CPU1.BB43 CPU1.BB55 CPU1.BB60 CPU1.BB64 CPU1.C5 CPU1.C25 CPU1.D6 CPU1.D10 CPU1.D11 CPU1.D14 CPU1.D18 CPU1.D22 CPU1.D25 CPU1.D26 CPU1.D30 CPU1.D34 CPU1.D39 CPU1.D44 CPU1.D45 CPU1.D47 CPU1.D48 CPU1.D53 CPU1.D58 CPU1.D62 CPU1.D66 CPU1.D69 CPU1.E6 CPU1.E11 CPU1.E15 CPU1.E18 CPU1.E21 CPU1.E46 CPU1.E50 CPU1.E53 CPU1.E56 CPU1.E65 CPU1.F1 CPU1.F2 CPU1.F4 CPU1.F8 CPU1.F13 CPU1.F22 CPU1.F23 CPU1.F27 CPU1.F28 CPU1.F32 CPU1.F33 CPU1.F35 CPU1.F37 CPU1.F38 CPU1.F40 CPU1.F42 CPU1.F68 CPU1.G5 CPU1.G6 CPU1.G10 CPU1.G22 CPU1.G43 CPU1.G45 CPU1.G48 CPU1.G52 CPU1.G55 CPU1.G58 CPU1.G60 CPU1.G63 CPU1.G66 CPU1.H15 CPU1.H18 CPU1.H71 CPU1.J8 CPU1.J11 CPU1.J13 CPU1.J25 CPU1.J28 CPU1.J32 CPU1.J35 CPU1.J38 CPU1.J42 CPU1.K16 CPU1.K18 CPU1.K22 CPU1.K61 CPU1.K63 CPU1.K64 CPU1.K65 CPU1.K66 CPU1.K67 CPU1.K68 CPU1.K70 CPU1.K71 CPU1.L2 CPU1.L4 CPU1.L8 CPU1.L11 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L20 CPU1.N6 CPU1.N10 CPU1.N13 CPU1.N19 CPU1.N21 CPU1.N65 CPU1.N68 CPU1.P17 CPU1.P19 CPU1.P20 CPU1.P21 CPU1.R6 CPU1.R13 CPU1.T2 CPU1.T4 CPU1.T15 CPU1.T17 CPU1.T18 CPU1.T21 CPU1.U10 CPU1.U63 CPU1.U64 CPU1.U66 CPU1.U67 CPU1.U69 CPU1.U70 CPU1.V16 CPU1.V17 CPU1.V18 CPU1.W6 CPU1.W9 CPU1.W13 CPU1.Y17 CPU1.Y19 CPU1.Y20 CPU1.Y21 D2601.A D4301.1 D4302.1 D4303.1 DB1.8 DB1.10 DB1.11 DB1.12 DB3.4 DB3.7 DB3.8 DCIN1.1 DCIN1.2 DCIN1.3 DCIN1.9 DCIN1.10 DIMM1.2 DIMM1.3 DIMM1.8 DIMM1.9 DIMM1.11 DIMM1.13 DIMM1.14 DIMM1.19 DIMM1.20 DIMM1.25 DIMM1.26 DIMM1.28 DIMM1.31 DIMM1.32 DIMM1.37 DIMM1.38 DIMM1.43 DIMM1.44 DIMM1.46 DIMM1.48 DIMM1.49 DIMM1.54 DIMM1.55 DIMM1.60 DIMM1.61 DIMM1.63 DIMM1.65 DIMM1.66 DIMM1.71 DIMM1.72 DIMM1.127 DIMM1.128 DIMM1.133 DIMM1.134 DIMM1.136 DIMM1.138 DIMM1.139 DIMM1.144 DIMM1.145 DIMM1.150 DIMM1.151 DIMM1.153 DIMM1.155 DIMM1.156 DIMM1.161 DIMM1.162 DIMM1.167 DIMM1.168 DIMM1.170 DIMM1.172 DIMM1.173 DIMM1.178 DIMM1.179 DIMM1.184 DIMM1.185 DIMM1.187 DIMM1.189 DIMM1.190 DIMM1.195 DIMM1.196 DIMM1.205 DIMM1.206 EC401.2 EC1001.2 EC1002.2 EC1003.2 EC1004.2 EC1005.2 EC1006.2 EC1007.2 EC1701.2 EC1702.2 EC1703.2 EC1704.2 EC1705.2 EC1706.2 EC1707.2 EC1708.2 EC1709.2 EC1711.2 EC1712.2 EC1801.2 EC1802.2 EC1803.1 EC1806.2 EC1807.2 EC1808.2 EC1901.1 EC1902.2 EC2101.2 EC2501.2 EC2502.2 EC2503.2 EC2504.2 EC2505.2 EC2506.2 EC2701.2 EC2703.2 EC2704.2 EC2705.2 EC2706.2 EC2707.2 EC2708.2 EC2709.2 EC2901.2 EC2902.2 EC2903.2 EC2904.2 EC4001.2 EC4301.2 EC4302.2 EC4303.2 EC4304.2 EC4305.2 EC4306.2 EC4307.1 EC5501.2 EC5502.2 EC5503.2 EC5504.2 EC5505.2 EC6501.2 EC6502.2 EC6503.2 EC6504.2 EC6601.2 EC6602.2 EC6603.2 EC8901.2 EC8902.2 EC8903.2 EC8904.2 EC8905.2 EC8906.2 EC8907.2 EC8908.2 EC8909.2 EC8910.2 EC8911.2 EC8912.2 EC8913.2 EC8914.2 EC8915.2 EC8916.2 EC8917.2 EC8918.2 EC8919.2 EC8920.2 EC8921.2 EC8922.2 EC8923.2 EC8924.2 EC8925.2 EC8926.2 EC8927.2 EC8928.2 EC8929.2 EC8930.2 EC8931.2 EC8932.2 EC8933.2 EC8934.2 EC8935.2 EC8936.2 EC8937.2 EC8938.2 ED501.2 ED1217.2 ED2901.1 ED2902.1 ED2903.1 ED2905.1 ED2906.1 EU3601.3 EU3602.2 EU3603.3 EU3604.2 FAN1.2 FAN1.5 FAN1.6 G1801.1 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 HDA27.43 HDD1.3 HDD1.4 HDD1.5 HDD1.6 HDD1.14 HDD1.17 HDD1.20 HDD1.21 HDD1.22 HDD1.23 HDD1.24 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HOMBD1.13 HOMBD1.16 HOMBD1.17 HOMBD1.18 HS1.1 HS2.1 HS3.1 IOBD1.3 IOBD1.6 IOBD1.18 IOBD1.21 IOBD1.24 IOBD1.32 IOBD1.51 IOBD1.52 IOBD1.53 IOBD1.54 IOBD1.55 JTAG1.10 JTAG1.11 JTAG1.12 KB1.1 KB1.27 KB1.28 KBC24.17 KBC24.51 KBC24.64 KBC24.84 KBC24.100 KBC24.124 KBLIT1.5 KBLIT1.6 LCD1.8 LCD1.11 LCD1.14 LCD1.17 LCD1.21 LCD1.28 LCD1.29 LCD1.32 LCD1.34 LCD1.41 LCD1.42 LCD1.43 LCD1.44 LCD1.45 LIDSW1.1 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC4301.2 PC4303.2 PC4304.2 PC4305.2 PC4306.2 PC4403.2 PC4407.2 PC4408.2 PC4409.2 PC4411.2 PC4413.2 PC4415.2 PC4420.2 PC4422.2 PC4425.2 PC4427.2 PC4430.2 PC4434.2 PC4435.2 PC4436.2 PC4437.2 PC4438.2 PC4439.2 PC4440.2 PC4441.2 PC4442.2 PC4509.2 PC4511.2 PC4512.2 PC4513.2 PC4515.2 PC4519.2 PC4520.2 PC4522.2 PC4524.2 PC4527.2 PC4610.2 PC4701.2 PC4702.2 PC4703.2 PC4704.2 PC4705.2 PC4707.2 PC4708.2 PC4709.2 PC4710.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4806.2 PC4807.2 PC4808.2 PC4810.2 PC5001.2 PC5002.2 PC5003.2 PC5004.2 PC5101.2 PC5102.2 PC5103.2 PC5104.2 PC5105.2 PC5106.2 PC5107.2 PC5108.2 PC5110.2 PC5111.2 PC5113.2 PC5114.2 PC5115.2 PC5116.2 PC5118.2 PC5119.2 PC5120.2 PC5138.2 PC5214.2 PC5215.2 PC5216.2 PC5219.2 PC5220.2 PC5221.2 PC5222.2 PC5223.2 PC5224.2 PC5225.2 PC5226.2 PC5301.2 PC5302.2 PC5303.2 PC5304.2 PC5306.2 PC5307.2 PC5308.2 PC5309.2 PD4301.3 PD4302.1 PD4303.A PD4304.A PG4410.2 PG4601.2 PQ4301.E PQ4407.1 PQ4407.4 PR4302.2 PR4309.2 PR4404.2 PR4419.2 PR4445.2 PR4471.2 PR4501.2 PR4502.2 PR4503.2 PR4517.2 PR4520.2 PR4652.2 PR4653.1 PR4656.1 PR4661.2 PR5104.2 PR5106.1 PR5209.1 PR5213.2 PR5301.2 PR5304.2 PT4501.2 PT4502.2 PT4701.2 PT4702.2 PT4703.2 PT4801.2 PT4802.2 PT4803.2 PU4401.22 PU4406.5 PU4406.6 PU4406.7 PU4501.3 PU4502.3 PU4503.21 PU4701.3 PU4701.5 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.31 PU4701.37 PU4803.5 PU4803.19 PU4803.20 PU4803.21 PU4803.22 PU4803.23 PU4803.24 PU4803.31 PU4803.37 PU5002.6 PU5002.9 PU5003.1 PU5003.2 PU5003.3 PU5101.9 PU5102.4 PU5102.8 PU5102.11 PU5202.9 PU5301.1 PU5302.2 Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q1802.S Q2408.S Q2505.S Q4007.S Q5704.S Q6501.S Q6503.S Q7001.1 Q7001.4 R402.2 R406.2 R407.2 R412.2 R413.2 R414.2 R415.2 R501.2 R502.2 R503.2 R601.2 R602.2 R604.2 R605.2 R720.2 R722.2 R734.2 R736.2 R1201.2 R1202.2 R1501.2 R1502.2 R1603.2 R1714.2 R1715.2 R1717.2 R1719.2 R1816.2 R1823.2 R1825.2 R1901.2 R2019.2 R2022.2 R2417.2 R2436.2 R2445.1 R2448.2 R2449.1 R2454.2 R2504.2 R2510.2 R2611.2 R2706.2 R2717.2 R3403.1 R3404.1 R3501.2 R4006.2 R4203.2 R4207.2 R4209.2 R4211.2 R4301.2 R5412.1 R5414.1 R5416.1 R5418.1 R5501.2 R5710.2 R6509.2 R6907.2 R6908.1 R6910.1 R6912.1 R6914.1 R6916.1 R6918.1 R7007.1 R7019.1 R9931.2 RN1703.1(A) RN1703.2(A) RN5502.1(A) RN5502.2(A) RN5502.3(A) RN5502.4(A) SKT251.4 SKT252.4 SPI251.4 SPI252.4 SPK1.5 SPK1.6 SPR1.1 SPR2.1 TC1201.2 TC3501.2 THM261.5 TP1.4 TP1.9 TP1.10 TP6901.1 U1701.3 U1702.5 U2901.1 U3401.14 U3401.17 U3501.2 U4001.11 U4001.15 U4002.3 U4004.3 U4005.3 U4006.5 U4006.9 U4101.1 U5501.2 U5701.8 U5701.15 U5701.35 U5701.41 U6001.3 U6001.8 U6901.8 U6901.23 U6901.35 U6901.47 U6901.49 U7001.5 U7001.6 U7001.7 U7001.8 U7002.5 U7002.6 U7002.7 U7002.8 USB1.4 USB1.7 USB1.11 USB1.12 USB1.13 USB1.14 USB2.4 USB2.7 USB2.10 USB2.11 USB2.12 USB2.13 X6901.2 X6901.4 XDP1.2 XDP1.7 XDP1.8 XDP1.13 XDP1.14 XDP1.19 XDP1.20 XDP1.25 XDP1.26 XDP1.31 XDP1.32 XDP1.37 XDP1.38 XDP1.49 XDP1.50 XDP1.59
V0.85A_VID0: CPU1.AN11 TP2101.1
V0.85A_VID1: CPU1.AN13 TP2102.1
VCC_CORE: C1101.1 C1102.1 C1103.1 C1116.1 C1117.1 CPU1.A30 CPU1.A34 CPU1.A39 CPU1.A44 CPU1.AK33 CPU1.AK35 CPU1.AK37 CPU1.AK38 CPU1.AK40 CPU1.AL33 CPU1.AL37 CPU1.AL40 CPU1.AM32 CPU1.AM33 CPU1.AM35 CPU1.AM37 CPU1.AM38 CPU1.G30 CPU1.G32 CPU1.G33 CPU1.G35 CPU1.G37 CPU1.G38 CPU1.G40 CPU1.G42 CPU1.J30 CPU1.J33 CPU1.J37 CPU1.J40 CPU1.K33 CPU1.K35 CPU1.K37 CPU1.K38 CPU1.K40 CPU1.K42 CPU1.K43 EC1001.1 EC1002.1 EC1003.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PG4708.2 PL4701.2 PT4701.1 PT4703.1 R719.1
VCC_SENSE: CPU1.E32 PR4648.1 R719.2
VCCGT_SENSE: CPU1.J70 PR4617.1 R721.2
VCCRTCEXT: C2112.1 CPU1.BB10
VCCSA_SENSE: CPU1.H20 PR4607.1 R735.2
VCCSTG_EN_R: C4033.1 R4017.2 U4002.2
VCCSTU_EN: EC4001.1 R4023.2 R4024.1 R4026.2 U4005.4
VCCSTU_EN_R: C4034.1 R4024.2 U4006.3
VDD_HDA: C2721.1 HDA27.3 R2701.1 R2713.2 R2727.2 R2918.1
VDD_IO: C2707.1 C2710.1 HDA27.9 R2715.2 R2723.1
VSS_AY71: CPU1.AY71 R602.1
VSS_SENSE: CPU1.E33 PR4645.1 R720.1
VSSGT_SENSE: CPU1.J69 PR4618.1 R722.1
VSSSA_SENSE: CPU1.H21 PR4604.2 R734.1
0D675V_PWR: PC5114.1 PR5119.1 PU5102.3 PU5102.5
0D675V_S0: C1214.1 C1215.1 C1216.1 DIMM1.203 DIMM1.204 PR5119.2
1D0V_S5: C1717.1 C2102.1 C2120.1 C4006.1 C4013.1 CPU1.AF18 CPU1.AF19 CPU1.V20 CPU1.V21 EC2101.1 PC1038.1 PC1039.1 PC5221.1 PC5222.1 PC5223.1 PC5224.1 PC5225.1 PG5209.1 PL5202.2 R1117.1 R2402.1 R9927.1 U1702.1 U1702.2 U1702.9 U4002.9 U4006.1 U4006.2 XDP1.43 XDP1.44
1D0V_S5_PWRGD: PR5211.1 R4029.1
1D5V_PWR: PC5309.1 PG5304.1 PU5302.5
1D5V_S0: PG5304.2 R2102.1 R2713.1 R5701.1
1D5V_VDD: C5702.2 C5704.2 C5705.2 C5706.2 C5716.2 R5701.2 U5701.12 U5701.19 U5701.20 U5701.31 U5701.40
1D8S_EN#: Q4007.D R4041.1 R4044.2
1D8S_EN_R#: C4022.2 Q4006.G R4041.2
1D8V_S5_PWROK: PR5308.1 R4030.1
1D35V_S3: C718.1 C719.1 C1207.1 C1208.1 C1209.1 C1210.1 C1211.1 C1212.1 C1213.1 C1220.1 C1221.1 C1222.1 CPU1.AL23 CPU1.AU23 CPU1.AU28 CPU1.AU35 CPU1.AU42 CPU1.BB23 CPU1.BB32 CPU1.BB41 CPU1.BB47 CPU1.BB51 DIMM1.75 DIMM1.76 DIMM1.81 DIMM1.82 DIMM1.87 DIMM1.88 DIMM1.93 DIMM1.94 DIMM1.99 DIMM1.100 DIMM1.105 DIMM1.106 DIMM1.111 DIMM1.112 DIMM1.117 DIMM1.118 DIMM1.123 DIMM1.124 EC8918.1 EC8919.1 EC8920.1 EC8921.1 EC8922.1 EC8923.1 EC8924.1 EC8925.1 EC8933.1 EC8934.1 EC8935.1 EC8936.1 EC8937.1 EC8938.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC5101.1 PC5102.1 PC5103.1 PC5104.1 PC5105.1 PC5112.1 PC5115.1 PC5118.1 PL5101.2 PR5103.1 PU5102.1 PU5102.2 R705.1 R1203.1 R4201.1 R4206.1 TC1201.1
1D35V_VTT_PWRGD: PR5107.1 R4011.1
3D3V_AUX_KBC_33: C2423.1 KBC24.54 R2462.1
3D3V_AUX_KBC_R: DB3.1 R2478.1
3D3V_AUX_S5: D2501.1 PG4533.1 PR4468.1 PR4522.1 Q2415.G R1726.2 R1727.1 R1737.1 R2452.2 R2463.1
3D3V_CAMERA_S0: C5503.1 EC5502.1 F5502.2 LCD1.40 R5513.2
3D3V_GSEN2: C7003.1 C7004.1 R7004.2 R7005.1 R7006.2 U7001.9 U7001.10
3D3V_MCU: C6901.1 C6903.1 C6904.1 C6905.1 C6906.1 C6907.1 R6901.2 R6902.2 R6909.2 R6911.2 R6913.2 R6915.2 R6917.2 R6919.2 RN6901.1(A) RN6901.2(A) TP6902.1 U6901.1 U6901.9 U6901.24 U6901.36 U6901.48
3D3V_RUN_FFS: C7006.1 C7007.1 R7011.2 R7020.1 U7002.2 U7002.9 U7002.10
3D3V_S0: C1203.1 C2601.1 C2602.1 C4004.1 C5502.1 C5701.2 C5703.2 DB1.1 DIMM1.199 EC8909.1 EC8910.1 EC8911.1 F5502.1 F5504.1 IOBD1.37 IOBD1.38 IOBD1.39 IOBD1.40 PR4614.1 PR5102.2 Q1801.2 Q1801.5 Q2414.G Q2601.2 Q2601.5 Q5502.G R405.1 R802.2 R1503.1 R1606.1 R1607.1 R1608.1 R1817.1 R1818.2 R1820.1 R1821.1 R1829.1 R1830.1 R1831.1 R1832.1 R1833.1 R1902.1 R2006.1 R2042.1 R2043.1 R2044.1 R2046.1 R2048.1 R2049.1 R2429.2 R2430.2 R2456.2 R2460.2 R2489.2 R2603.1 R2604.1 R2609.1 R2715.1 R2727.1 R4005.1 R5411.1 R5413.1 R5415.1 R5417.1 R5419.1 R5420.1 R5513.1 R5515.1 R5518.1 R6502.1 R6901.1 R7004.1 R7011.1 R7018.1 RN801.1(A) RN801.2(A) RN803.1(A) RN803.2(A) RN1810.1(A) RN1810.2(A) RN2007.3(B) RN2007.4(B) RN2008.3(B) RN2008.4(B) RN2602.1(A) RN2602.2(A) THM261.1 U4001.8 U4001.9 U5501.4 U5501.5 U5701.11 U5701.37
3D3V_S5: C1702.1 C2415.1 C2416.1 C2421.1 C4014.1 C4015.1 C4102.1 C6502.1 C7002.1 EC8912.1 IOBD1.42 IOBD1.43 IOBD1.44 LIDSW1.2 PC4519.1 PC5303.1 PC5308.1 PD4302.2 PG4530.1 PL4502.1 PR4305.1 PR4424.1 PR4519.1 PR5110.1 PR5118.2 PR5212.1 PR5214.2 PR5302.1 PT4502.1 PU5301.5 PU5301.9 PU5302.1 Q2412.G Q2413.G Q6502.S R1709.1 R1711.1 R1724.1 R2409.2 R2433.2 R2434.1 R2446.1 R2461.1 R2484.2 R2488.2 R2498.2 R2499.2 R2607.1 R4026.1 R4031.1 R4101.1 R5721.1 R7001.2 R9909.1 R9929.1 U1701.5 U4001.6 U4001.7 U4004.5 U4005.5 U4101.2 U4101.3
3D3V_S5_KBC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2417.1 C2420.1 C2422.1 C2429.1 D4301.2 D4302.2 D4303.2 KBC24.5 KBC24.19 KBC24.22 KBC24.43 KBC24.65 KBC24.82 KBC24.103 KBC24.115 PR4414.1 PR4432.1 R2403.1 R2414.2 R2415.2 R2420.1 R2424.2 R2425.1 R2427.2 R2438.1 R2439.1 R2441.1 R2442.1 R2443.1 R2446.2 R2450.2 R2453.1 R2455.2 R2462.2 R2473.2 R2478.2 R2480.2 R2495.2 R2608.1 R4032.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2409.1(A) RN2409.2(A) RN2409.3(A) RN2409.4(A) RN2410.1(A) RN2410.2(A) RN2410.3(A) RN2410.4(A) RN2411.1(A) RN2411.2(A) RN2411.3(A) RN2411.4(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A) RN2603.1(A) RN2603.2(A)
3D3V_S5_PCH: C4101.1 Q2604.2 Q2604.5 R404.1 R1110.1 R1814.1 R1822.1 R1824.1 R1834.1 R1835.1 R1836.1 R1837.1 R2007.1 R2039.1 R2040.1 R2041.1 R2501.2 R2502.2 R2515.1 R2516.1 R4101.2 R4103.2 RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A)
3D3V_SEN_S0: C5515.1 EC5505.1 F5504.2 HOMBD1.1 R5515.2
3D3V_SPIVCC1: C2501.1 C2502.1 R2515.2 SKT251.8 SPI251.8
3D3V_SPIVCC2: C2504.1 C2505.1 R2516.2 SKT252.8 SPI252.8
81208_AGND: PC4609.1 PC4613.1 PC4615.2 PC4619.1 PC4626.2 PC4628.2 PC4629.2 PC4630.2 PC4631.2 PC4632.2 PC4633.1 PG4601.1 PR4602.2 PR4611.2 PR4613.2 PR4615.2 PR4628.2 PR4635.2 PR4636.1 PR4658.2 PR4659.2 PR4660.2 PR4662.2 PR4663.2 PR4664.2 PR4672.1 PU4601.49 R9934.2
+DC_IN: AFTP4303.1 AFTP4304.1 AFTP4316.1 DCIN1.6 DCIN1.7 DCIN1.8 EC4301.1 EC4302.1 EC8913.1 PC4301.1 PC4302.1 PD4303.K PR4308.1 PU4301.1 PU4301.2 PU4301.3
+RTC_VCC: D2501.2 IOBD1.36 Q2505.G R2504.1
+SDC_IN: PG4406.1 PR4426.1 PR4435.1 PR4439.1 PU4405.1 PU4405.2 PU4405.3
+V_VREF_PATH1: C4202.2 R4211.1
+V_VREF_PATH3: C4201.2 R4207.1
+VCHGR: PC4415.1 PC4420.1 PC4439.1 PC4440.1 PD4402.3 PG4403.2 PR4443.2 PU4403.1 PU4403.2 PU4403.3
A5_TP: CPU1.A5 TP2309.1
A67_TP: CPU1.A67 TP2311.1
A70_TP: CPU1.A70 TP2310.1
AC_PRESENT: CPU1.AY15 D2404.A EC1707.1 Q1702.3 R1709.2
ACAV_IN: KBC24.128 R2469.2
ACOK_IN: PQ4407.2 PR4475.1
AD+: PC4303.1 PC4304.1 PC4305.1 PC4306.1 PD4406.A PR4418.1 PR4444.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4405.5 PU4405.6 PU4405.7 PU4405.8
AD+_G_1: PQ4407.5 PQ4407.6 PR4423.1
AD+_G_2: PR4423.2 PR4435.2 PU4405.4
AD_IA: PR4472.1 R2421.1
ALERT#: R2603.2 THM261.6
ALL_SYS_PWRGD: D4002.1 EC1709.1 R1716.1 R2481.1 R4002.1 R4005.2 R4011.2 U1701.2 U4004.4
ALS_INT#: CPU1.BA9 LCD1.33 R1902.2 R6927.2
ALS_INT#_HUB: R6927.1 U6901.28
ALWON: KBC24.121 R4009.2
AUD_AGND: AFTP2908.1 C2729.1 C2730.1 EC2703.1 EC2704.1 EC2705.1 EC2706.1 EC2707.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 EC8901.1 EC8902.1 EC8903.1 EC8904.1 HDA27.27 HPMIC1.6 HPMIC1.MS R2706.1 R2919.2 R2920.2 U2901.4
AUD_HP1_JACK_L: C2907.2 HDA27.23 R2908.1 R2921.2
AUD_HP1_JACK_L1: EC2907.1 R2907.1 R2908.2 R2919.1
AUD_HP1_JACK_R: C2908.2 HDA27.24 R2910.1
AUD_HP1_JACK_R1: EC2908.1 R2909.1 R2910.2 R2920.1
AUD_PC_BEEP: C2720.2 HDA27.36
AUD_PC_BEEP_C: C2720.1 R2717.1 R2721.2
AUD_PC_BEEP_R: D2701.3 R2721.1
AUD_PORTA_L_R_B: AFTP2906.1 ED2902.2 HPMIC1.1 R2907.2
AUD_PORTA_R_R_B: AFTP2907.1 ED2901.2 HPMIC1.2 R2909.2
AUD_SENSE_A: HDA27.35 R2916.2 R2924.2
AUD_SPK_L+: HDA27.12 R2902.1
AUD_SPK_L+_C: AFTP2902.1 EC2902.1 R2902.2 SPK1.3
AUD_SPK_L-: HDA27.14 R2901.1
AUD_SPK_L-_C: AFTP2901.1 EC2901.1 R2901.2 SPK1.4
AUD_SPK_R+: HDA27.17 R2904.1
AUD_SPK_R+_C: AFTP2904.1 EC2904.1 R2904.2 SPK1.1
AUD_SPK_R-: HDA27.15 R2903.1
AUD_SPK_R-_C: AFTP2903.1 EC2903.1 R2903.2 SPK1.2
AUX_EN_WOWL: CPU1.BB17 IOBD1.35
B71_TP: CPU1.B71 TP2312.1
BA1_TP: CPU1.BA1 TP2305.1
BA2_TP: CPU1.BA2 TP2306.1
BA71_TP: CPU1.BA71 TP2303.1
BAT1_LED#: KBC24.1 Q2412.S R2484.1
BAT2_LED#: KBC24.106 Q2413.S R2488.1
BATDRV#: PC4424.2 PR4409.2 PU4403.4
BATT_WHITE_LED#: IOBD1.26 Q2412.D
BB67_TP: CPU1.BB67 TP2302.1
BB70_TP: CPU1.BB70 TP2301.1
BEEP: KBC24.45 RN2701.1(A)
BKLGT_PWM: KBC24.44 Q6501.G R6509.1
BKLT_CTRL: D5502.3 R5502.1 RN5501.5(B) RN5502.5(B)
BLON_OUT: KBC24.30 RN5501.7(B)
BLON_OUT_C: LCD1.25 RN5501.2(A) RN5502.6(B)
BOARD_ID: C2408.2 KBC24.111 R2443.2 R2444.1 R2468.1 R2494.2
BOOST_MON: PR4473.1 R2423.1
BP_PWRGD_RST#: C9901.1 R9926.2 XDP1.41
BQ24770_AGND: PC4401.2 PC4402.2 PC4410.2 PC4412.2 PC4416.1 PC4418.1 PC4432.2 PC4433.2 PG4410.1 PR4411.2 PU4401.29
BT+: AFTP4310.1 AFTP4311.1 AFTP4312.1 BATT1.1 BATT1.2 EC4303.1 EC4304.1 PC4424.1 PC4438.1 PD4304.K PD4402.1 PD4402.2 PD4405.A PR4408.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8
BT_RADIO_DIS#: CPU1.AB2 IOBD1.34 R2042.2
C1_TP: CPU1.C1 TP2308.1
CAM_MIC_CBL_DET#: CPU1.W4 LCD1.27
CAP_LED: AFTP6525.1 KB1.2 R6513.2
CAP_LED#: KBC24.93 Q2414.S R2489.1
CAP_LED#_R: Q2414.D R6512.1
CAP_LED_Q: Q6505.C R6513.1
CAP_LED_R#: Q6505.B R6512.2
CBN: C2715.2 HDA27.20
CBP: C2715.1 HDA27.19
CFG: R5420.2 U5701.23
CFG0: CPU1.E68 R9608.1 XDP1.9
CFG1: CPU1.B67 XDP1.11
CFG2: CPU1.D65 XDP1.15
CFG3: CPU1.D67 R604.1 R9902.1 XDP1.17
CFG4: CPU1.E70 R605.1 XDP1.27
CFG5: CPU1.C68 XDP1.29
CFG6: CPU1.D68 XDP1.33
CFG7: CPU1.C67 XDP1.35
CFG8: CPU1.F71 XDP1.10
CFG9: CPU1.G69 XDP1.12
CFG10: CPU1.F70 XDP1.16
CFG11: CPU1.G68 XDP1.18
CFG12: CPU1.H70 XDP1.28
CFG13: CPU1.G71 XDP1.30
CFG14: CPU1.H69 XDP1.34
CFG15: CPU1.G70 XDP1.36
CFG16: CPU1.E63 XDP1.6
CFG17: CPU1.F63 XDP1.4
CFG18: CPU1.E66 XDP1.24
CFG19: CPU1.F66 XDP1.22
CFG_RCOMP: CPU1.E60 R601.1
CHARGER_SRC: PC4407.1 PC4411.1 PC4413.1 PC4425.1 PC4427.1 PC4434.1 PG4402.1 PR4426.2 PU4406.2 PU4406.3 PU4406.4 PU4406.10
CHG_AMBER_LED#: IOBD1.25 Q2413.D
CLK_PCI_LPC: DB1.9 EC1802.1 R1804.2
CLK_PCI_LPC_MEC: EC1801.1 KBC24.57 R1805.2
CLK_TP_SIO: EC6501.1 KBC24.78 RN6501.4(B) RN6502.2(A)
CLKREQ_PCIE#1: CPU1.AT7 IOBD1.33 R1829.2
CLKREQ_PCIE#2: CPU1.AT8 R1830.2
CLKREQ_PCIE#3: CPU1.AT10 R1831.2
CLKREQ_PCIE#4: CPU1.AU8 R1832.2
CLKREQ_PCIE#5: CPU1.AU7 R1833.2
CLKREQ_PEG#0: CPU1.AR10 R1817.2
CLKRUN#: KBC24.63 R1819.2 R2510.1
CLKRUN#_R: CPU1.AW11 R1818.1 R1819.1
CMP_VIN0: KBC24.20 R2470.2
CMP_VIN0_R: C2612.1 C2613.1 R2470.1 R2494.1 R2608.2 R2609.2 R2610.1
CMP_VOUT0: KBC24.85 R2476.1 R2602.2 R2607.2 R2615.2
CMP_VOUT1: KBC24.83 Q2408.G R2417.1 R2418.1 R2475.1
CODEC_BITCLK_R: C2723.2 HDA27.40 R2720.2
CODEC_SDOUT_R: HDA27.1 R2719.2
CP_VNEG: C2724.2 HDA27.21
CP_VPOS: C2725.2 HDA27.22
CPU_A16_TP: CPU1.BB9 TP1902.1
CPU_D1_TP: CPU1.M2 TP1801.1
CPU_D4_TP: CPU1.V1 TP1804.1
CPU_D5_TP: CPU1.V2 TP1805.1
CPU_D6_TP: CPU1.M1 TP1806.1
CPU_DP1_CTRL_CLK: CPU1.L13 RN801.3(B) U5701.38
CPU_DP1_CTRL_DATA: CPU1.L12 RN801.4(B) U5701.39
CPU_DP1_HPD: CPU1.L9 U5701.3
CPU_DP2_CTRL_CLK: CPU1.N7 RN803.4(B)
CPU_DP2_CTRL_DATA: CPU1.N8 RN803.3(B)
CPU_POPIRCOMP: CPU1.AT16 R412.1
CSI2_COMP: CPU1.E13 R1501.1
CTL1: R3401.2 U3401.6
CTL2: R3406.2 U3401.7
CTL3: R3402.2 U3401.8
DAT_TP_SIO: EC6502.1 KBC24.79 RN6501.3(B) RN6502.1(A)
DBC_EN_R: LCD1.22 R5503.1
DBC_PANEL_EN: CPU1.AM5 R2043.2 R5503.2
DC_IN_D: PQ4407.3 PR4418.2

# Allegro board 14296-1.0727WZS1940.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R6920  0R0402-PAD-2-GP  [0R0402-PAD-1]  93.33 103.63 90 bottom
R6921  0R0402-PAD-2-GP  [0R0402-PAD-1]  82.84 112.49 270 top
R6922  0R0402-PAD-2-GP  [0R0402-PAD-1]  82.84 111.6 270 top
R6923  0R0402-PAD-2-GP  [0R0402-PAD-1]  92.95 105.25 180 bottom
R6924  0R0402-PAD-2-GP  [0R0402-PAD-1]  79.18 105.76 180 top
R6925  0R0402-PAD-2-GP  [0R0402-PAD-1]  85.76 111.42 270 top
R6926  0R0402-PAD-2-GP  [0R0402-PAD-1]  79.53 107.54 180 top
R6927  0R0402-PAD-2-GP  [0R0402-PAD-1]  83.47 107.92 180 top
R6928  0R0402-PAD-2-GP  [0R0402-PAD-1]  88.42 99.54 0 top
R6929  0R0402-PAD-2-GP  [0R0402-PAD-1]  89.8 99.33 0 top
R7001  100KR2J-1-GP  [R402H16]  16.16 71.34 0 top
R7002  0R2J-2-GP  [R402H16]  93.76 105 180 bottom
R7003  0R0402-PAD-2-GP  [0R0402-PAD-1]  91.85 104.13 180 bottom
R7004  0R0402-PAD-2-GP  [0R0402-PAD-1]  163.23 16.99 180 top
R7005  10KR2J-3-GP  [R402H16]  160.81 23.59 0 top
R7006  10KR2J-3-GP  [R402H16]  161.7 23.59 0 top
R7007  0R0402-PAD-2-GP  [0R0402-PAD-1]  162.57 23.59 0 top
R7008  0R0402-PAD-2-GP  [0R0402-PAD-1]  146.59 38.32 270 bottom
R7009  0R0402-PAD-2-GP  [0R0402-PAD-1]  160.56 25.88 0 top
R7010  0R0402-PAD-2-GP  [0R0402-PAD-1]  162.34 25.88 0 top
R7011  0R3J-6-GP  [R603H22]  156.62 23.59 0 top
R7012  0R0402-PAD-2-GP  [0R0402-PAD-1]  159.67 25.88 0 top
R7013  0R0402-PAD-2-GP  [0R0402-PAD-1]  161.45 25.88 0 top
R7014  0R2J-2-GP  [R402H16]  124.24 100.42 90 top
R7015  0R2J-2-GP  [R402H16]  158.78 25.88 180 top
R7016  0R2J-2-GP  [R402H16]  126.02 100.93 90 top
R7017  0R2J-2-GP  [R402H16]  159.04 18.13 180 top
R7018  100KR2J-1-GP  [R402H16]  152.18 16.48 270 top
R7019  0R2J-2-GP  [R402H16]  155.48 21.94 180 top
R7020  10KR2J-3-GP  [R402H16]  154.59 21.94 0 top
R9608  1KR2J-1-GP  [R402H16]  101.2 29.52 90 top
R9902  1KR2J-1-GP  [R402H16]  97.19 29.56 90 top
R9904  1KR2J-1-GP  [R402H16]  105.29 29.18 180 top
R9906  150R2J-L1-GP-U  [R402H16]  107.93 29.18 180 top
R9909  3KR2J-2-GP  [R402H16]  108.74 29.18 180 top
R9911  0R0402-PAD-2-GP  [0R0402-PAD-1]  110.62 29.18 180 top
R9912  0R0402-PAD-2-GP  [0R0402-PAD-1]  112.48 29.08 180 top
R9913  0R0402-PAD-2-GP  [0R0402-PAD-1]  102.17 40.68 90 top
R9914  0R0402-PAD-2-GP  [0R0402-PAD-1]  114.92 29.13 0 top
R9915  0R0402-PAD-2-GP  [0R0402-PAD-1]  116.36 29.46 0 top
R9916  0R0402-PAD-2-GP  [0R0402-PAD-1]  110.14 43.78 180 top
R9917  0R0402-PAD-2-GP  [0R0402-PAD-1]  116.24 38.96 180 top
R9919  0R0402-PAD-2-GP  [0R0402-PAD-1]  109.55 41.37 0 top
R9923  0R0402-PAD-2-GP  [0R0402-PAD-1]  102.17 41.57 90 top
R9925  0R0402-PAD-2-GP  [0R0402-PAD-1]  107.93 41.37 180 top
R9926  0R0402-PAD-2-GP  [0R0402-PAD-1]  105.62 27.88 90 top
R9927  0R0402-PAD-2-GP  [0R0402-PAD-1]  105.7 40.45 270 top
R9929  100KR2J-1-GP  [R402H16]  117 31.72 180 top
R9931  0R2J-2-GP  [R402H16]  116.11 31.72 0 top
R9932  1K5R2J-3-GP  [R402H16]  106.86 44.04 90 top
R9933  0R0402-PAD-2-GP  [0R0402-PAD-1]  106.59 43.21 270 top
R9934  25K5R2F-GP  [R402H16]  31.43 47.21 90 top
RN801  SRN2K2J-1-GP  [ARES2H16]  73.69 83.41 180 top
RN803  SRN2K2J-1-GP  [ARES2H16]  76.74 82.39 180 top
RN1601  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  64.27 76.47 90 bottom
RN1702  SRN0J-6-GP  [SMD-ARES4H20]  97.06 84.04 90 top
RN1703  SRN10KJ-5-GP  [ARES2H18]  101.18 73.96 90 top
RN1801  SRN20KJ-1-GP  [SMD-ARES4H20]  107.35 89.88 180 top
RN1806  SRN0J-7-GP-U  [ARES8-CN24H22]  99.35 77.18 270 top
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  78.14 86.58 180 top
RN1810  SRN10KJ-5-GP  [ARES2H18]  122.21 97.63 0 top
RN1811  SRN2K2J-1-GP  [ARES2H16]  78.39 90.77 180 top
RN2007  SRN1KJ-7-GP  [SMD-ARES4H18]  74.07 88.11 90 top
RN2008  SRN2K2J-1-GP  [ARES2H16]  74.07 86.07 90 top
RN2402  SRN4K7J-8-GP  [SMD-ARES4H18]  139.35 31.21 180 top
RN2403  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  154.46 33.5 90 top
RN2404  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  154.72 36.29 90 top
RN2409  SRN100KJ-5-GP  [ARES8-CN24H20]  154.46 30.57 90 top
RN2410  SRN100KJ-5-GP  [ARES8-CN24H20]  154.46 27.65 90 top
RN2411  SRN100KJ-5-GP  [ARES8-CN24H20]  154.46 24.73 90 top
RN2412  SRN100KJ-5-GP  [ARES8-CN24H20]  156.5 30.57 270 top
RN2602  SRN2K2J-1-GP  [ARES2H16]  103.66 91.41 270 top
RN2603  SRN2K2J-1-GP  [ARES2H16]  144.05 67.15 270 top
RN2701  SRN0J-6-GP  [SMD-ARES4H20]  28.23 37.56 90 bottom
RN4301  SRN100J-4-GP  [ARES8-CN24H20]  91.6 22.57 180 top
RN5501  SRN100J-4-GP  [ARES8-CN24H20]  51.14 92.93 180 top
RN5502  SRN100KJ-5-GP  [ARES8-CN24H20]  53.3 99.54 180 top
RN6501  SRN10KJ-5-GP  [ARES2H18]  111.03 26.69 180 top
RN6502  SRN33J-5-GP-U  [SMD-ARES4H18]  109 26.69 180 top
RN6503  SRN2K2J-1-GP  [ARES2H16]  114.08 26.76 180 top
RN6801  SRN0J-7-GP-U  [ARES8-CN24H22]  108.11 105 0 top
RN6901  SRN2K2J-1-GP  [ARES2H16]  99.73 98.27 180 top
RN7001  SRN0J-6-GP  [SMD-ARES4H20]  103.16 97.76 270 top
SKT251  SKT-G6179HT0321-001-GP  [G6179HT0321-001]  123.65 107.54 270 bottom
SKT252  SKT-G6179HT0321-001-GP  [G6179HT0321-001]  137.37 93.54 0 bottom
SPI251  MX25L6473EM21-10G-GP  [SOIC8-1H86]  123.65 107.54 90 bottom
SPI252  MX25L3273EM2I-10G-GP  [SOIC8-1H86]  137.37 93.54 180 bottom
SPK1  ACES-CON4-29-GP  [50224-0040N-001]  12.8 5.5 180 bottom
SPR1  SPRING-13-GP-U  [SPR7837H229]  108.8 107 0 bottom
SPR2  SPRING-13-GP-U  [SPR7837H229]  133.8 65.2 270 bottom
TC1201  ST330U2VDM-4-GP-U  [CT7343H83]  136.94 60.29 270 bottom
TC3501  SC100U6D3V6MX-GP  [C1206H71]  20.28 49.62 0 bottom
THM261  NCT7718W-GP  [MSOP8-1H44]  69.5 39.21 0 top
TP1  ACES-CON8-66-GP  [51574-0084N-W01]  111.8 21 180 bottom
TP401  TPAD14-OP-GP  [TPAD14-OP]  72.04 48.35 0 top
TP402  TPAD14-OP-GP  [TPAD14-OP]  65.69 41.12 180 bottom
TP403  TPAD14-OP-GP  [TPAD14-OP]  66.24 82.96 180 bottom
TP404  TPAD14-OP-GP  [TPAD14-OP]  97.31 80.61 180 bottom
TP501  TPAD14-OP-GP  [TPAD14-OP]  87.28 55.09 0 top
TP502  TPAD14-OP-GP  [TPAD14-OP]  87.13 59.23 0 top
TP601  TPAD14-OP-GP  [TPAD14-OP]  93.89 39.46 180 bottom
TP602  TPAD14-OP-GP  [TPAD14-OP]  98.2 39.97 180 bottom
TP603  TPAD14-OP-GP  [TPAD14-OP]  95.66 41.37 180 bottom
TP604  TPAD14-OP-GP  [TPAD14-OP]  96.93 41.24 180 bottom
TP605  TPAD14-OP-GP  [TPAD14-OP]  83.47 75.66 0 top
TP606  TPAD14-OP-GP  [TPAD14-OP]  83.85 77.56 0 top
TP607  TPAD14-OP-GP  [TPAD14-OP]  97.19 82.14 180 bottom
TP608  TPAD14-OP-GP  [TPAD14-OP]  87.28 79.98 0 top
TP609  TPAD14-OP-GP  [TPAD14-OP]  95.54 80.61 180 bottom
TP610  TPAD14-OP-GP  [TPAD14-OP]  98.33 81.37 180 bottom
TP611  TPAD14-OP-GP  [TPAD14-OP]  95.66 82.39 180 bottom
TP612  TPAD14-OP-GP  [TPAD14-OP]  71.58 46.95 0 top
TP613  TPAD14-OP-GP  [TPAD14-OP]  72.78 47.16 0 top
TP614  TPAD14-OP-GP  [TPAD14-OP]  91.35 39.59 180 bottom
TP615  TPAD14-OP-GP  [TPAD14-OP]  92.62 39.34 180 bottom
TP616  TPAD14-OP-GP  [TPAD14-OP]  87.79 51.78 0 top
TP617  TPAD14-OP-GP  [TPAD14-OP]  86.52 51.78 0 top
TP701  TPAD14-OP-GP  [TPAD14-OP]  75.37 65.32 90 top
TP707  TPAD14-OP-GP  [TPAD14-OP]  83.95 64.67 0 top
TP801  TPAD14-OP-GP  [TPAD14-OP]  66.2 56.86 90 bottom
TP1601  TPAD14-OP-GP  [TPAD14-OP]  73.06 88.36 180 bottom
TP1602  TPAD14-OP-GP  [TPAD14-OP]  72.42 87.22 180 bottom
TP1603  TPAD14-OP-GP  [TPAD14-OP]  71.66 89.76 180 bottom
TP1604  TPAD14-OP-GP  [TPAD14-OP]  71.28 87.72 180 bottom
TP1703  TPAD14-OP-GP  [TPAD14-OP]  95.66 73.63 180 bottom
TP1704  TPAD14-OP-GP  [TPAD14-OP]  90.3 75.38 0 top
TP1705  TPAD14-OP-GP  [TPAD14-OP]  69.64 44.97 0 top
TP1706  TPAD14-OP-GP  [TPAD14-OP]  87.15 75.67 0 top
TP1707  TPAD14-OP-GP  [TPAD14-OP]  91.09 78.45 0 top
TP1708  TPAD14-OP-GP  [TPAD14-OP]  85.83 78.42 0 top
TP1801  TPAD14-OP-GP  [TPAD14-OP]  74.84 88.49 90 bottom
TP1802  TPAD14-OP-GP  [TPAD14-OP]  74.71 89.76 180 bottom
TP1804  TPAD14-OP-GP  [TPAD14-OP]  79 88.56 180 bottom
TP1805  TPAD14-OP-GP  [TPAD14-OP]  78.9 87.34 180 bottom
TP1806  TPAD14-OP-GP  [TPAD14-OP]  74.84 87.22 180 bottom
TP1902  TPAD14-OP-GP  [TPAD14-OP]  95.66 79.34 180 bottom
TP2006  TPAD14-OP-GP  [TPAD14-OP]  76.11 87.22 180 bottom
TP2011  TPAD14-OP-GP  [TPAD14-OP]  76.23 90.26 180 bottom
TP2012  TPAD14-OP-GP  [TPAD14-OP]  77.38 87.22 180 bottom
TP2013  TPAD14-OP-GP  [TPAD14-OP]  77.5 90.26 180 bottom
TP2014  TPAD14-OP-GP  [TPAD14-OP]  76.11 88.49 180 bottom
TP2015  TPAD14-OP-GP  [TPAD14-OP]  81.57 87.09 180 bottom
TP2016  TPAD14-OP-GP  [TPAD14-OP]  80.93 88.16 180 bottom
TP2017  TPAD14-OP-GP  [TPAD14-OP]  80.3 87.09 180 bottom
TP2018  TPAD14-OP-GP  [TPAD14-OP]  85.96 87.85 180 bottom
TP2101  TPAD14-OP-GP  [TPAD14-OP]  87.15 77.5 0 top
TP2102  TPAD14-OP-GP  [TPAD14-OP]  85.83 76.58 0 top
TP2301  TPAD14-OP-GP  [TPAD14-OP]  98.2 41.24 180 bottom
TP2302  TPAD14-OP-GP  [TPAD14-OP]  99.47 41.24 180 bottom
TP2303  TPAD14-OP-GP  [TPAD14-OP]  99.47 39.97 180 bottom
TP2304  TPAD14-OP-GP  [TPAD14-OP]  90.08 42.77 0 top
TP2305  TPAD14-OP-GP  [TPAD14-OP]  96.93 83.66 180 bottom
TP2306  TPAD14-OP-GP  [TPAD14-OP]  95.66 83.66 180 bottom
TP2307  TPAD14-OP-GP  [TPAD14-OP]  93.58 87.17 180 bottom
TP2308  TPAD14-OP-GP  [TPAD14-OP]  70.14 87.22 180 bottom
TP2309  TPAD14-OP-GP  [TPAD14-OP]  66.22 85.62 180 bottom
TP2310  TPAD14-OP-GP  [TPAD14-OP]  67.34 38.07 180 bottom
TP2311  TPAD14-OP-GP  [TPAD14-OP]  66.07 38.07 180 bottom
TP2312  TPAD14-OP-GP  [TPAD14-OP]  68.99 37.81 180 bottom
TP2313  TPAD14-OP-GP  [TPAD14-OP]  73.31 39.85 180 bottom
TP2702  TPAD14-OP-GP  [TPAD14-OP]  28.48 24.61 0 top
TP2703  TPAD14-OP-GP  [TPAD14-OP]  26.07 25.49 0 top
TP4401  TPAD14-OP-GP  [TPAD14-OP]  42.58 6.06 0 top
TP4402  TPAD14-OP-GP  [TPAD14-OP]  44.1 7.21 0 top
TP4601  TPAD14-OP-GP  [TPAD14-OP]  32.54 53.94 0 top
TP4603  TPAD14-OP-GP  [TPAD14-OP]  39.9 42.14 180 bottom
TP6901  TPAD14-OP-GP  [TPAD14-OP]  97.06 107.28 0 top
TP6902  TPAD14-OP-GP  [TPAD14-OP]  98.58 107.28 0 top
TP6903  TPAD14-OP-GP  [TPAD14-OP]  82.84 102.96 0 top
TP6904  TPAD14-OP-GP  [TPAD14-OP]  83.47 101.69 0 top
TP9901  TPAD14-OP-GP  [TPAD14-OP]  66.28 55.64 180 bottom
TP9902  TPAD14-OP-GP  [TPAD14-OP]  66.2 53.31 180 bottom
TR3602  DLP11SN900HL2L-GP  [L125100-4P-4H37]  21.5 59.4 180 bottom
TR3603  DLP11SN900HL2L-GP  [L125100-4P-4H37]  23.02 41.24 180 bottom
TR5501  DLP11SN900HL2L-GP  [L125100-4P-4H37]  57.94 99.54 270 top
TR6601  DLP11SN900HL2L-GP  [L125100-4P-4H37]  155.61 61.56 90 top
TR6602  DLP11SN900HL2L-GP  [L125100-4P-4H37]  153.07 61.56 90 top
U1701  74LVC1G07GW-GP  [SC70-5H44]  65.31 41.62 0 top
U1702  AOZ1334DI-01-GP  [DFN8F3-G2517H32]  60.89 86.43 0 top
U2901  2N7002KDW-GP  [SOT-363H44]  19.84 30.96 270 bottom
U3401  TPS2544RTER-GP  [QFN16-G1D8-UH32]  23.53 54.32 0 bottom
U3501  SY6288DAAC-GP  [SOT-23-5H56]  23.65 49.62 90 bottom
U4001  G5016KD1U-GP  [DFN14J3020-G255D85H32]  30.39 91.15 180 top
U4002  M5938ARD1U-GP-U  [DFN8F3-G2416-1H32]  64.51 91.32 90 top
U4004  74LVC1G07GW-GP  [SC70-5H44]  37.24 88.92 270 bottom
U4005  74LVC1G07GW-GP  [SC70-5H44]  62.26 73.12 0 bottom
U4006  TPS22965DSGR-GP-U  [DFN8G2-G1710-U1H32]  63.05 83.53 270 bottom
U4101  SY6288C10CAC-GP  [MSOP8-1H44]  74.96 108.68 180 top
U5501  RT9724GB-GP  [SOT-23-5H51]  49.44 99.54 270 top
U5701  PS8407ATQFN40GTR2-A1-GP  [QFN40J5-G3D65H32]  15.78 80.23 90 bottom
U6001  AZ1045-04F-R7G-GP  [DFN10G2510H26]  122.08 27.4 90 bottom
U6901  STM32L151CBU6TR-1-GP  [QFN48G7-G5D7H26]  89.44 105.5 270 top
U7001  LNG2DMTR-GP  [LGA12G2H40]  161.83 20.03 270 top
U7002  LNG2DMTR-GP  [LGA12G2H40]  155.99 19.02 0 top
USB1  SKT-USB14-5-GP-U  [SKT-USB14-160155-U]  3.8 62.95 90 bottom
USB2  SKT-USB13-90-GP-U  [SKT-USB13-158172-1]  3.18 44.95 90 bottom
X1801  XTAL-24MHZ-81-GP  [OSC-3225-4P-4H36]  57.82 66.39 180 bottom
X1802  XTAL-32D768KHZ-67-GP  [SMD49-6914-0403H56]  96.65 101.14 0 bottom
X2401  XTAL-32D768KHZ-83-GP  [SMD49-3215-0713H36]  148.11 31.59 90 bottom
X6901  XTAL-12MHZ-67-GP  [OSC-3225-4P-4H36]  98.71 104.23 90 top
XDP1  PAD-60P-GP  [PAD-60P]  104.55 35.15 0 top

## Library data of the parts
AFTP2601-AFTP2604 AFTP2901-AFTP2904 AFTP2906-AFTP2908 AFTP2910 AFTP4301-AFTP4316 AFTP4501 AFTP6501-AFTP6537 = AFTE14P-75: tolerance: ZZ.AFT14.101
BATT1 = C144KA-108A7-L-1: tolerance: 20.81775.008
C715 C1207 C1208 C1704 C1717 C2601 C4006 C4009 C4012 C7007 PC1055-PC1057 PC5115 PC5303 = C603H38: tolerance: 78.10610.5BL
C716 C717 C719 C1101-C1103 C1116 C1117 C1136 C1138 C1147-C1154 C1172-C1175 C1180 C1212-C1216 C1718 C1719 C1805 C1806 C2101-C2109 C2116 C2117 C2120 C2121 C2418 C2419 C2426 C2721 C2722 C2729 C2730 C3508 C4022 C4031-C4034 C4101 C4102 C6901 EC1006 PC4631 PC4708 PC4808 PC5110 PC5111 PC5113 PC5219 PC5301 PC5308 PC5309 = C402H22: tolerance: 78.10523.5FL
C718 C720 C721 C1201-C1204 C1206 C1210 C1218 C1220-C1222 C1702 C2110-C2112 C2118 C2406 C2408 C2410-C2414 C2416 C2420-C2423 C2428 C2429 C2502 C2504 C2602 C2608-C2610 C2612 C2707 C2709 C2711-C2713 C2720 C2727 C3502 C3507 C4007 C4008 C4014-C4017 C4026 C4027 C5707-C5715 C6002 C6501-C6503 C7002 C7006 C9901-C9905 EC1707 EC1712 EC1806-EC1808 EC1902 EC2708 EC2709 EC4001 PC5102 PC5116 PC5118-PC5120 PC5138 PC5307 = C402H22: tolerance: 78.10421.2FL
C1104 C1106 C1108 C1182 C1184 C2113-C2115 C2119 C2122 PC1001-PC1039 PC1041-PC1054 PC1062 PC1063 PC1065-PC1098 PC5114 = C603H40: tolerance: 78.22610.5BL
C1176 C1183 C2902 C2903 C2907 C2908 = C603H36: tolerance: 78.10613.5BL
C1205 C2415 C2417 C2710 C2715 C2724-C2726 C2728 C6004 PC4422 PC4707 PC4807 PC5001 PC5226 = C603H36: tolerance: 78.22523.5BL
C1209 EC8923-EC8925 PC1058-PC1061 PC4301 = C603H36: tolerance: 78.10422.2BL
C1211 EC2703 EC2705 EC4304 EC5502 EC8901 EC8903 EC8907-EC8917 EC8919-EC8922 EC8936-EC8938 PC4401 PC4412 PC4413 PC4416 PC4418 PC4428 PC4429 PC4433 PC4610 PC4628 PC4630 PC4710 PC4810 PC5004 PC5117 PC5217 = C402H22: tolerance: 78.10422.5FL
C1601 C1602 = C402H22: tolerance: 78.10421.2FL; signal model: C402H22_SCD1U10V2KX-5GP
C1701 PC4613 PC5112 PC5218 = C402H22: tolerance: 78.22124.2FL
C1710 C2503 C2701 = C402H22: tolerance: 78.47423.5FL
C1711 C2409 C6903-C6905 PC4303-PC4305 PC4402 PC4424 PC4601 PC4626 PC4629 PC5107 = C402H22: tolerance: 78.10324.2FL
C1801 C1802 C6908 C6909 = C402H22: tolerance: 78.15034.1FL
C1803 C1804 = C402H22: tolerance: 78.3R074.1FL
C2402 C2403 EC401 EC1701-EC1705 EC1708 EC1709 EC1711 ED501 ED1217 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
C2405 C2613 EC2905-EC2908 PC4435-PC4437 = C402H22: tolerance: 78.10134.1FL
C2424 C2425 EC1801 EC1802 EC1901 EC2503 EC2505 EC2701 EC4305-EC4307 PC4617 = C402H22: tolerance: 78.10034.1FL
C2427 C2435 C2441 C2603 C2607 EC8906 EC8933-EC8935 PC4607 PC4612 PC4618 PC4634 = C402H22: tolerance: 78.22224.2FL
C2501 C2505 C4004 C4005 C4013 = C805H54: tolerance: 78.10623.51L
C2604 C2706 C2708 C5503 C5515 PC4524 PC4527 = C603H36: tolerance: 78.47520.5BL
C2605 C3402 C3403 C5701-C5706 C5716 C6902 C6906 C6907 C7003 PC5221 = C402H22: tolerance: 78.10423.2FL
C2606 = C603H36: tolerance: 78.47134.1BL
C2714 EC1706 EC2704 EC2706 EC2707 EC2901-EC2904 EC4302 EC8902 EC8904 EC8918 PC4603 PC4605 PC4608 PC4611 PC4620 PC4622 PC4625 PC4627 PC4632 PC4633 PC5220 = C402H22: tolerance: 78.10224.2FL
C2723 EC5503 EC5504 = C402H22: tolerance: 78.22034.1FL
C2901 C3401 = C402H22: tolerance: 78.10520.5FL
C3404 TC3501 = C1206H71: tolerance: 78.10710.52L
C3512 C3513 PC1064 PC5101 PC5103-PC5105 PC5222-PC5225 PC5302 PC5304 = C805H58: tolerance: 78.22610.51L
C3601 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C3601
C3602 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C3602
C3603 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C3603
C3604 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C3604
C4001 C4002 PC4609 PC4614 PC4615 = C402H22: tolerance: 78.47124.2FL
C4201 C4202 = C402H22: tolerance: 78.22321.2FL
C5501 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C5501
C5502 C5505 = C603H36: tolerance: 78.47520.L0L
C5504 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C5504
C5506 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C5506
C5507 = C402H22: tolerance: 78.10423.L1L
C5508 = C402H22: tolerance: 78.10520.LAL
C5509 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C5509
C5510 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C5510
C5511 = C402H22: tolerance: 78.10423.2FL; signal model: Graser_C5511
C5512 C5516 PC4517 PC4518 = C603H36: tolerance: 78.10424.L0L
C5513 = C402H22: tolerance: 78.10224.L1L
C5514 C5517 = C805H58: tolerance: 78.47522.L4L
C6001 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6001
C6003 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6003
C6005 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6005
C6006 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6006
C7001 = C402H22: tolerance: 78.47321.2FL
C7004 = C603H38: tolerance: 78.10610.L0L
CPU1 = BGA1356M4224-U2H52: tolerance: 071.SKYLA.000U
D401 D2402-D2404 = SOD323AKH38: tolerance: 83.R2004.G8F
D2501 = SOT-23-9H44: tolerance: 75.00040.07D
D2601 = SOD323AKH44: tolerance: 083.55130.008F
D2701 D5501 D5502 = SOT23-2D4-312H48: tolerance: 75.00054.E7D
D4001 = SOT-23-13H46: tolerance: 83.00016.F11
D4002 = SOT23-2D4-312H44: tolerance: 83.00016.K11
D4301-D4303 PD4302 = SOT23-2D8-312H56: tolerance: 75.03101.07D
D5701 = SOT-23-10H44: tolerance: 75.00056.07D
D7001 = SOT23-2D4-312H48: tolerance: 75.00054.R7D
DB1 = DM-HS81100-01: tolerance: ZZ.D0075.11001
DB3 = 50696-00601-001: tolerance: 20.K0691.006
DCIN1 = 50224-0080N-W02: tolerance: 20.F1295.008
DIMM1 = DS2RK-20401-TP4B-U: tolerance: 62.10024.M31
EC1001-EC1005 EC1007 EC2101 = C402H22: tolerance: 78.10422.L1L
EC1803 EC2501 EC2502 EC2504 EC2506 = C402H22: tolerance: 78.4R7B4.1FL
EC4301 = C603H40: tolerance: 78.10612.5BL
EC4303 = C603H36: tolerance: 78.10424.2BL
EC5501 = C402H22: tolerance: 78.6R864.1FL
EC5505 EC6501-EC6504 EC6601-EC6603 = C402H22: tolerance: 78.33034.1FL
EC8905 EC8926-EC8932 PC4302 PC4410 PC4420 PC4432 PC4438 = C603H36: tolerance: 78.10522.5BL
ED2901-ED2903 ED2905 ED2906 = SOD-523-4H28: tolerance: 75.02025.077
EU3601 EU3603 = LGA9G2310H13: tolerance: 83.3V3U4.0A0
EU3602 EU3604 = SOT-6H58: tolerance: 75.09904.07C
F5501 F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
F5502 F6501 = POLYSW-2114H50: tolerance: 69.50007.921
F5504 F5701 = POLYSW-2114H30: tolerance: 69.48001.081
FAN1 SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
G1801 = CON2O-U: tolerance: ZZ.CON2O.XXX
H1 H5 H6 = HOLE335R178: tolerance: ZZ.00PAD.7F1
H2-H4 = HOLE335R229: tolerance: ZZ.00PAD.7G1
HDA27 = QFN42J5-G3D6H36: tolerance: 071.06008.0003
HDD1 = GS12201-1011-9H: tolerance: 20.F1546.020
HDMI1 = SKT-HDMI23-178125-1: tolerance: 22.10296.431
HOMBD1 = AYF531635: tolerance: 020.K0028.0016
HPMIC1 = 2SJ3095-013111F: tolerance: 022.10002.0521
HS1-HS3 = STF237R128H42: tolerance: 34.4WZ01.201
IOBD1 = 50398-05071-001: tolerance: 020.F0285.0050
JTAG1 = 50675-01001-001: tolerance: 20.K0460.010
KB1 = 50588-02601-001-U: tolerance: 20.K0615.026
KBC24 = TQFP128-2H48: tolerance: 071.01404.000E
KBLIT1 = 51575-00401-W01: tolerance: 20.K0800.004
LCD1 = 50398-04071-001: tolerance: 20.F2037.040
LIDSW1 = SOT23-2D8-123H52: tolerance: 74.05712.0BB
PC4306 PC4403 PC4407-PC4409 PC4411 PC4415 PC4425 PC4427 PC4430 PC4434 PC4439-PC4442 PC4509 PC4511 PC4512 PC4515 PC4522 PC4701-PC4705 PC4802-PC4806 PC5002 PC5003 PC5106 PC5108 PC5214 PC5216 = C805H56: tolerance: 78.10622.51L
PC4414 = C402H22: tolerance: 78.22224.L0L
PC4421 PC4623 = C402H22: tolerance: 78.47322.2FL
PC4513 PC5215 = C402H22: tolerance: 78.10324.L0L
PC4519 PC4520 = C402H22: tolerance: 78.10421.L0L
PC4602 PC4606 PC5306 = C402H22: tolerance: 78.47224.2FL
PC4604 = C402H22: tolerance: 78.15034.L1L
PC4616 = C402H22: tolerance: 78.33322.2FL
PC4619 = C402H22: tolerance: 78.15134.1FL
PC4621 = C402H20: tolerance: 78.56034.1FL
PC4706 PC4809 PC5005 = C603H40: tolerance: 78.22422.2BL
PC4709 = C603: tolerance: 78.33124.2BL
PC5305 = C402H22: tolerance: 78.68034.1FL
PD4301 = SOT-23-10H44: tolerance: 83.0024V.0A1
PD4303 = D5436AKH98: tolerance: 83.22R03.03G
PD4304 = SOD123FLAKH40: tolerance: 83.SMF18.0AH
PD4401 PD4405 PD4406 = SOD323AKH40: tolerance: 83.1R504.B8F
PD4402 = SMPC4665-3P-UH48: tolerance: 83.8R010.A87
PG4401-PG4403 PG4406-PG4408 PG4410 PG4530-PG4534 PG4601 PG4707 PG4708 PG4808 PG4809 PG5001 PG5011 PG5209 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG5304 = GAP-CLOSE-PWR: tolerance: ZZ.CON2d.XXX
PL4401 = L11510030H158: tolerance: 68.2R210.20C
PL4501 = L7066-1830-UH119: tolerance: 68.3R310.20A
PL4502 = L4240-D815-UH79: tolerance: 68.1R510.20J
PL4701 PL4801 = L6965-1530H158: tolerance: 68.R1510.10H
PL5001 = L4240-D815-UH79: tolerance: 68.R4710.20G
PL5101 = L4947-1115H119: tolerance: 68.1R010.20R
PL5202 = L686647-127318H119: tolerance: 68.R681A.10A
PQ4301 Q2603 = SOT23CBE2D6H46: tolerance: 84.03904.P11
PQ4302 = SOT23DGS2D4H44: tolerance: 84.00301.A31
PQ4407 Q1701 Q1702 Q1801 Q2601 Q2604 Q6504 Q7001 U2901 = SOT-363H44: tolerance: 84.2N702.A3F
PR4301 PR4425 PR5119 R703 R1110 R1117 R1139 R1711 R2106-R2111 R2446 R2713 R2715 R2722 R2725 R2901-R2904 R2906 R2907 R2909 R2911 R4103 R5701 R5715 R6514 R6901 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
PR4302 PR4515 = R402H16: tolerance: 64.15025.6DL
PR4303 R802 R1503 R1606-R1608 R1701 R1707 R1709 R1714 R1717 R1723 R1724 R1726 R1814 R1816 R1817 R1820 R1821 R1829-R1833 R1902 R2022 R2039-R2044 R2415 R2425 R2427 R2429 R2430 R2438 R2439 R2441 R2442 R2453 R2456 R2460 R2473 R2498 R2499 R2607 R2701 R2704 R2919 R2920 R4009 R4026 R4044 R5721 R6511 R6908-R6919 R7005 R7006 R7020 = R402H16: tolerance: 63.10334.1DL
PR4304 PR4410 PR4435 PR4449 PR4470 PR4471 PR4522 PR5212 R404 R405 R603 R1715 R1722 R1727 R1737 R2409 R2417 R2433 R2434 R2436 R2449-R2452 R2454 R2455 R2461 R2480 R2484 R2488 R2489 R2495 R2496 R2723 R2918 R3501 R4031 R4032 R6509 R6902 R7001 R7018 R9929 = R402H16: tolerance: 63.10434.1DL
PR4305 R1836 R2921 R5706 R5707 = R402H16: tolerance: 63.22234.1DL
PR4306 R2716 R5504 R5505 = R402H16: tolerance: 63.33034.1DL
PR4308 = R603H22: tolerance: 63.24434.15L
PR4309 = R603H22: tolerance: 63.47333.15L
PR4403 = R805H24: tolerance: 63.10031.16L
PR4404 = R402H16: tolerance: 63.12434.1DL
PR4408 = R603H22: tolerance: 64.20R05.55L
PR4409 PR4601 PR4619 PR4624 PR4626 PR4671 PR5108 = R402H16: tolerance: 64.10015.6DL
PR4411 R1719 = R402H16: tolerance: 64.47025.6DL
PR4413 PR4415 PR4421 PR5106 PR5111 PR5117 PR5118 PR5307 R410 R1704 R1708 R1718 R1720 R1728 R2020 R2021 R2101 R2418 R2440 R2447 R2457 R2459 R2468 R2471 R2475-R2477 R2491-R2494 R2601 R2615 R4033 R4204 R4210 R5502 R6505 R6506 R6801 R6802 R7002 R7014-R7017 R7019 R9931 = R402H16: tolerance: 63.R0034.1DL
PR4414 PR4432 = R402H16: tolerance: 63.33234.1DL
PR4417 PR4438 PR4469 PR4472-PR4475 PR4521 PR4527 PR4604 PR4607 PR4618 PR4630 PR4632 PR4645 PR4648 PR4650 PR4655 PR4666 PR4670 PR4672 PR4703 PR4807 PR5102 PR5105 PR5107 PR5114 PR5125 PR5209 PR5211 PR5214 PR5215 PR5305 PR5306 PR5308 R602 R709 R732 R1201 R1202 R1204 R1706 R1713 R1729 R1732 R1733 R1810 R1813 R1819 R1828 R2102 R2401 R2402 R2410-R2412 R2416 R2431 R2435 R2445 R2458 R2462 R2464-R2467 R2469 R2470 R2472 R2474 R2478 R2479 R2481-R2483 R2485-R2487 R2490 R2497 R2515 R2516 R2602 R2611-R2614 R2714 R3401 R3402 R3405 R3406 R4002 R4010 R4011 R4017 R4023 R4024 R4029 R4030 R4036 R4038 R4042 R4102 R4301 R5501 R5503 R5516 R5722 R5723 R6001 R6002 R6510 R6512 R6920-R6929 R7003 R7004 R7007-R7010 R7012 R7013 R9911-R9917 R9919 R9923 R9925-R9927 R9933 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR4418 = R1206H28: tolerance: 63.33232.11L
PR4419 = R603H22: tolerance: 64.4R705.55L
PR4423 PR4614 PR4663 R2448 R2510 R5518 = R402H16: tolerance: 64.10025.6DL
PR4424 PR5213 PR5302 R1716 R2444 = R402H16: tolerance: 64.10035.6DL
PR4426 = R3720H40: tolerance: 64.R0105.7FL
PR4439 = R402H16: tolerance: 64.40215.6DL
PR4443 = R2512H32: tolerance: 64.R0105.97L
PR4444 = R402H16: tolerance: 64.28735.6DL
PR4445 = R402H16: tolerance: 64.33025.6DL
PR4468 PR5103 = R402H16: tolerance: 64.15035.6DL
PR4501 = R402H16: tolerance: 64.16025.6DL
PR4502 = R402H16: tolerance: 64.62025.6DL
PR4503 = R402H16: tolerance: 63.20134.1DL
PR4508 PR4509 = R603H22: tolerance: 64.1R505.55L
PR4512 PR4652 PR4661 = R402H16: tolerance: 64.66515.6DL
PR4517 = R402H15: tolerance: 64.10025.L0L
PR4519 = R402H15: tolerance: 63.10434.L1L
PR4520 = R402H16: tolerance: 64.97615.6DL
PR4602 = R402H16: tolerance: 64.20015.6DL
PR4605 = R402H16: tolerance: 64.82505.6DL
PR4606 PR4633 PR4653 PR4656 = NTC-402H24-U: tolerance: 69.60028.011
PR4608 = R402H16: tolerance: 64.78705.6DL
PR4609 PR4629 = R402H16: tolerance: 64.14025.6DL
PR4611 = R402H16: tolerance: 64.14725.6DL
PR4612 PR4627 = R603H22: tolerance: 64.75015.55L
PR4613 = R402H16: tolerance: 64.34025.6DL
PR4615 R2424 R3403 R4006 R6504 = R402H16: tolerance: 64.20025.6DL
PR4617 R1801 R1812 R1908 R1911 R2719 R2720 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: R402H16_0R2J-2-GP
PR4621 = R402H16: tolerance: 64.45R35.6DL
PR4622 = R402H16: tolerance: 64.75R05.6DL
PR4623 PR4668 R503 R719-R722 R726 R734 R735 R1501 R1604 R2905 R2912 R2913 R2922 = R402H14: tolerance: 64.10005.6DL
PR4625 = R402H16: tolerance: 64.37R45.6DL
PR4628 = R402H16: tolerance: 64.10535.60L
PR4631 = R402H16: tolerance: 64.47515.6DL
PR4634 = NTC-402H24-U: tolerance: 69.60028.031
PR4635 = R402H16: tolerance: 64.51025.6DL
PR4636 R6904 = R402H16: tolerance: 64.15015.6DL
PR4637 = R603H22: tolerance: 64.59025.55L
PR4638 = R402H16: tolerance: 64.16535.6DL
PR4639 = R402H16: tolerance: 64.75025.6DL
PR4640 = R402H16: tolerance: 64.12425.6DL
PR4644 = R402H16: tolerance: 64.42205.6DL
PR4646 PR4667 R2404-R2406 R2503 R2505-R2509 R2511-R2514 R2609 R2908 R2910 = R402H14: tolerance: 64.10R05.6DL
PR4647 = R402H16: tolerance: 64.34815.6DL
PR4651 = R402H16: tolerance: 64.48715.6DL
PR4657 = R402H16: tolerance: 63.2R234.1DL
PR4658 = R402H16: tolerance: 64.90925.6DL
PR4659 PR4664 = R402H16: tolerance: 64.24025.6DL
PR4660 = R402H16: tolerance: 64.15825.6DL
PR4662 = R402H16: tolerance: 64.48725.6DL
PR4665 = R402H16: tolerance: 64.49R95.L0L
PR4669 = R402H16: tolerance: 64.24915.6DL
PR4701 PR4802 = R603H22: tolerance: 63.3R934.15L
PR4702 PR4803 = R402H16: tolerance: 64.2R205.6DL
PR4704 = R805H24: tolerance: 64.2R205.16L
PR5001 PR5101 = R603H22: tolerance: 64.2R205.55L
PR5104 = R402H16: tolerance: 64.12035.6DL
PR5110 R401 R417 R419 R604 R605 R1702 R1703 R1822-R1827 R1834 R1835 R1909 R2006 R2007 R2019 R2432 R2463 R2717 R2721 R4005 R5517 R6513 R9608 R9902 R9904 = R402H16: tolerance: 63.10234.1DL
PR5210 = R603H22: tolerance: 63.2R233.15L
PR5216 = R402H16: tolerance: 64.68025.6DL
PR5217 = R402H15: tolerance: 63.R0034.L0L
PR5301 = R402H16: tolerance: 63.47334.1DL
PR5303 = R402H16: tolerance: 64.16525.6DL
PR5304 = R402H16: tolerance: 64.13325.6DL
PT4501 PT4502 = CT3528H79: tolerance: 77.C2271.45L
PT4701 PT4703 PT4801 PT4802 = CT3528H79: tolerance: 80.3371V.A2L
PT4702 PT4803 = CT7343H119: tolerance: 77.23361.061
PU4301 PU4403 PU4405 = PPAK-8P-2H45: tolerance: 84.07121.037
PU4401 = QFN28-G2D7H32: tolerance: 074.24770.0B03
PU4406 = PPAK-8P-G5324H44-COLAY: tolerance: ZZ.00215.037
PU4501 PU4502 = SON5Z3025H18: tolerance: 84.87381.03G
PU4503 = QFN20-G1D75H32: tolerance: 74.51225.073
PU4601 = LFQFN48J6-G4D6H40: tolerance: 074.81208.0B73
PU4701 PU4803 = QFN36J4060-G2554H40: tolerance: 074.81382.0AE3
PU5001 PU5003 = PPAK-8P-2H45: tolerance: 84.00412.037
PU5002 = LFDFN8G2-G1309H40: tolerance: 074.81253.00E3
PU5101 = QFN10M3-G4P-UH34: tolerance: 74.08206.C73
PU5102 = MSOP10-G2D5H44: tolerance: 74.05338.079
PU5202 = QFN10M3-G4P-UH34: tolerance: 74.08208.K73
PU5301 = SOIC8-G3530H63: tolerance: 74.05930.03D
PU5302 = SOT-23-5H52: tolerance: 74.01339.B3F
Q1802 Q2408 Q2412-Q2415 Q2505 Q2602 Q4007 Q5502 Q5704 Q6503 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
Q4006 Q6502 = SOT23DGS2D4H48: tolerance: 84.02130.031
Q6501 = SOT23DGS2D8H56: tolerance: 84.P8503.031
Q6505 = SOT23CBE2D4H44: tolerance: 84.00144.N11
R402 R406-R409 R416 R421-R423 = R402H16: tolerance: 63.51034.1DL
R403 = R402H16: tolerance: 64.49905.6DL
R412-R415 R601 R2403 = R402H16: tolerance: 64.49R95.6DL
R501 = R402H16: tolerance: 64.12105.6DL
R502 = R402H16: tolerance: 64.80R65.6DL
R705 R2706 = 0R0805-PAD-1-U: tolerance: ZZ.00PAD.M31
R723 = R402H16: tolerance: 64.54R95.6DL
R727 = R402H16: tolerance: 63.56034.1DL
R728 = R402H16: tolerance: 63.22134.1DL
R736 R5506 = R402H14: tolerance: 63.10134.1DL
R801 R4207 R4211 = R402H16: tolerance: 64.24R95.6DL
R1203 = R402H16: tolerance: 64.47005.6DL
R1502 R1901 = R402H16: tolerance: 64.20005.6DL
R1603 = R402H16: tolerance: 64.11305.6DL
R1730 = R402H16: tolerance: 63.33434.1DL
R1731 R4041 R6907 = R402H16: tolerance: 63.20334.1DL
R1734 = 0R1206-PAD-1: tolerance: ZZ.R1206.ZZ1
R1802 = R402H16: tolerance: 63.10534.1DL
R1803 = R402H16: tolerance: 64.27015.6DL
R1804 = R402H16: tolerance: 63.22034.1DL; signal model: R402H16_0R2J-2-GP
R1805 = R402H16: tolerance: 63.22034.1DL; signal model: R402H16_33R2J-2-GP
R1806 = R402H14: tolerance: 64.10R05.6DL; signal model: R402H16_33R2J-2-GP
R1807-R1809 R1811 = R402H14: tolerance: 64.10R05.6DL; signal model: R402H16_0R2J-2-GP
R1815 R2504 = R402H16: tolerance: 63.10634.1DL
R1818 = R402H16: tolerance: 64.82015.6DL
R1837 = R402H16: tolerance: 63.15434.1DL
R1907 R1912 = R402H16: tolerance: 63.33034.1DL; signal model: R402H16_33R2J-2-GP
R2046 R2048 R2049 = R402H16: tolerance: 63.51334.1DL
R2414 R2501 R2502 R5411-R5420 = R402H16: tolerance: 63.47234.1DL
R2419 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: R402H16_33R2J-2-GP
R2420 = R402H16: tolerance: 63.10334.1DL; signal model: R402H16_33R2J-2-GP
R2421 = R402H16: tolerance: 63.33134.1DL
R2422 R2423 = R402H16: tolerance: 63.33134.1DL; signal model: R402H16_33R2J-2-GP
R2437 = R402H16: tolerance: 63.43034.1DL
R2443 = R402H16: tolerance: 64.64925.6DL
R2603 R2604 = R402H16: tolerance: 64.75015.6DL
R2608 R9934 = R402H16: tolerance: 64.25525.6DL
R2610 = NTC-603H38: tolerance: 69.60035.041
R2718 = R402H16: tolerance: 63.33034.1DL; signal model: R402H16_0R2J-2-GP
R2726 R2727 R2917 R5716 R6501 R6502 = R603H22: tolerance: 63.00000.00L
R2915 = R402H16: tolerance: 63.47434.1DL
R2916 = R402H16: tolerance: 64.49915.6DL
R2924 = R402H16: tolerance: 64.13025.6DL
R3404 = R402H16: tolerance: 64.22125.6DL
R3605 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3605
R3606 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3606
R3609 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3609
R3610 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3610
R3611 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3611
R3612 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3612
R3613 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3613
R3614 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3614
R4101 = R805H24: tolerance: 63.R0031.16L
R4201 R4203 R4206 R4209 = R402H16: tolerance: 64.18015.6DL
R4202 R4208 = R402H16: tolerance: 64.2R005.6DL
R5507 R5513 R5515 R7011 = R603H22: tolerance: 63.R0033.15L
R5510 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21; signal model: Graser_R5510
R5511 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21; signal model: Graser_R5511
R5514 = R1206H26: tolerance: 63.R0037.L0L
R5702-R5705 R9906 = R402H16: tolerance: 63.15134.1DL
R5710 = R402H16: tolerance: 63.43234.1DL
R6503 = R603H22: tolerance: 63.10133.15L
R6605 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R6605
R6606 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R6606
R6905 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R6905
R6906 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R6906
R9909 = R402H16: tolerance: 63.30234.1DL
R9932 = R402H16: tolerance: 63.15234.1DL
RN801 RN803 RN1811 RN2008 RN2602 RN2603 RN6503 RN6901 = ARES2H16: tolerance: 66.22236.04L
RN1601 RN2403 RN2404 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1702 RN2701 RN7001 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN1703 RN1810 RN6501 = ARES2H18: tolerance: 66.10336.04L
RN1801 = SMD-ARES4H20: tolerance: 66.20336.04L
RN1806 = ARES8-CN24H22: tolerance: 66.R0036.A8L; signal model: ARES8-CN24H22_SRN0J-7-GP-U
RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN2007 = SMD-ARES4H18: tolerance: 66.10236.04L
RN2402 = SMD-ARES4H18: tolerance: 66.47236.04L
RN2409-RN2412 RN5502 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN4301 RN5501 = ARES8-CN24H20: tolerance: 66.10136.A8L
RN6502 = SMD-ARES4H18: tolerance: 66.33036.04L
RN6801 = ARES8-CN24H22: tolerance: 66.R0036.A8L
SKT251 SKT252 = G6179HT0321-001: tolerance: 62.10089.011
SPI251 = SOIC8-1H86: tolerance: 72.25647.00A
SPI252 = SOIC8-1H86: tolerance: 72.25327.A01
SPR1 SPR2 = SPR7837H229: tolerance: 34.43E24.001
TC1201 = CT7343H83: tolerance: 79.33719.20L
THM261 = MSOP8-1H44: tolerance: 74.07718.0B9
TP1 = 51574-0084N-W01: tolerance: 020.K0151.0008
TP401-TP404 TP501 TP502 TP601-TP617 TP701 TP707 TP801 TP1601-TP1604 TP1703-TP1708 TP1801 TP1802 TP1804-TP1806 TP1902 TP2006 TP2011-TP2018 TP2101 TP2102 TP2301-TP2313 TP2702 TP2703 TP4401 TP4402 TP4601 TP4603 TP6901-TP6904 TP9901 TP9902 = TPAD14-OP: tolerance: ZZ.PAD14.001
TR3602 TR3603 TR5501 TR6601 TR6602 = L125100-4P-4H37: tolerance: 68.11900.201
U1701 U4004 U4005 = SC70-5H44: tolerance: 73.01G07.0HG
U1702 = DFN8F3-G2517H32: tolerance: 074.01334.0093
U3401 = QFN16-G1D8-UH32: tolerance: 74.02544.073
U3501 = SOT-23-5H56: tolerance: 074.06288.009B
U4001 = DFN14J3020-G255D85H32: tolerance: 074.05016.0093
U4002 = DFN8F3-G2416-1H32: tolerance: 074.05938.0093
U4006 = DFN8G2-G1710-U1H32: tolerance: 74.22965.093
U4101 = MSOP8-1H44: tolerance: 074.06288.0079
U5501 = SOT-23-5H51: tolerance: 74.09724.09F
U5701 = QFN40J5-G3D65H32: tolerance: 071.08407.0003
U6001 = DFN10G2510H26: tolerance: 75.01045.073
U6901 = QFN48G7-G5D7H26: tolerance: 071.32151.0B0U
U7001 U7002 = LGA12G2H40: tolerance: 074.LNG2D.00BZ
USB1 = SKT-USB14-160155-U: tolerance: 022.10005.0441
USB2 = SKT-USB13-158172-1: tolerance: 22.10341.A81
X1801 = OSC-3225-4P-4H36: tolerance: 82.30004.841
X1802 = SMD49-6914-0403H56: tolerance: 82.30001.G11
X2401 = SMD49-3215-0713H36: tolerance: 082.30003.0131
X6901 = OSC-3225-4P-4H36: tolerance: 82.30006.641
XDP1 = PAD-60P: tolerance: ZZ.00PAD.Q81

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD-1
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0603-PAD-1-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0805-PAD-1-U
  rect 1.549x1.333 smd: 1(0,0.838) 2(0,-0.838)
0R1206-PAD-1
  rect 1.854x2.057 smd: 1(0,1.397) 2(0,-1.397)
2SJ3095-013111F
  oval 1.321x2.235 hole 0.61x1.524: 1(-4.85,8.4) 2(4.7,2.9) 3(-4.85,0.6) 4(4.7,0) 5(4.7,8.4) 6(4.7,5.65) MS(-4.85,4.3)
50224-0040N-001
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.797,0) 6(2.797,0)
50224-0080N-W02
  rect 0.406x1.549 smd: 1(-3.5,3.875) 2(-2.5,3.875) 3(-1.5,3.875) 4(-0.5,3.875) 5(0.5,3.875) 6(1.5,3.875) 7(2.5,3.875) 8(3.5,3.875)
  rect 1.194x1.803 smd: 9(-4.797,0) 10(4.797,0)
50398-04071-001
  rect 0.305x1.295 smd: 1(-9.75,-1.95) 2(-9.25,-1.95) 3(-8.75,-1.95) 4(-8.25,-1.95) 5(-7.75,-1.95) 6(-7.25,-1.95) 7(-6.75,-1.95) 8(-6.25,-1.95) 9(-5.75,-1.95) 10(-5.25,-1.95) 11(-4.75,-1.95) 12(-4.25,-1.95) 13(-3.75,-1.95) 14(-3.25,-1.95) 15(-2.75,-1.95) 16(-2.25,-1.95) 17(-1.75,-1.95) 18(-1.25,-1.95) 19(-0.75,-1.95) 20(-0.25,-1.95) 21(0.25,-1.95) 22(0.75,-1.95) 23(1.25,-1.95) 24(1.75,-1.95) 25(2.25,-1.95) 26(2.75,-1.95) 27(3.25,-1.95) 28(3.75,-1.95) 29(4.25,-1.95) 30(4.75,-1.95) 31(5.25,-1.95) 32(5.75,-1.95) 33(6.25,-1.95) 34(6.75,-1.95) 35(7.25,-1.95) 36(7.75,-1.95) 37(8.25,-1.95) 38(8.75,-1.95) 39(9.25,-1.95) 40(9.75,-1.95)
  rect 1.194x3.2 smd: 41(-12.15,0) 45(12.15,0)
  rect 2.311x1.295 smd: 42(-8.9,1.95) 43(0,1.95) 44(8.9,1.95)
50398-05071-001
  rect 0.305x1.295 smd: 1(-12.25,-1.95) 2(-11.75,-1.95) 3(-11.25,-1.95) 4(-10.75,-1.95) 5(-10.25,-1.95) 6(-9.75,-1.95) 7(-9.25,-1.95) 8(-8.75,-1.95) 9(-8.25,-1.95) 10(-7.75,-1.95) 11(-7.25,-1.95) 12(-6.75,-1.95) 13(-6.25,-1.95) 14(-5.75,-1.95) 15(-5.25,-1.95) 16(-4.75,-1.95) 17(-4.25,-1.95) 18(-3.75,-1.95) 19(-3.25,-1.95) 20(-2.75,-1.95) 21(-2.25,-1.95) 22(-1.75,-1.95) 23(-1.25,-1.95) 24(-0.75,-1.95) 25(-0.25,-1.95) 26(0.25,-1.95) 27(0.75,-1.95) 28(1.25,-1.95) 29(1.75,-1.95) 30(2.25,-1.95) 31(2.75,-1.95) 32(3.25,-1.95) 33(3.75,-1.95) 34(4.25,-1.95) 35(4.75,-1.95) 36(5.25,-1.95) 37(5.75,-1.95) 38(6.25,-1.95) 39(6.75,-1.95) 40(7.25,-1.95) 41(7.75,-1.95) 42(8.25,-1.95) 43(8.75,-1.95) 44(9.25,-1.95) 45(9.75,-1.95) 46(10.25,-1.95) 47(10.75,-1.95) 48(11.25,-1.95) 49(11.75,-1.95) 50(12.25,-1.95)
  rect 1.194x3.2 smd: 51(-14.65,0) 55(14.65,0)
  rect 2.311x1.295 smd: 52(-11.4,1.95) 53(0,1.95) 54(11.4,1.95)
50588-02601-001-U
  rect 0.406x1.092 smd: 1(12.5,2.15) 2(11.5,2.15) 3(10.5,2.15) 4(9.5,2.15) 5(8.5,2.15) 6(7.5,2.15) 7(6.5,2.15) 8(5.5,2.15) 9(4.5,2.15) 10(3.5,2.15) 11(2.5,2.15) 12(1.5,2.15) 13(0.5,2.15) 14(-0.5,2.15) 15(-1.5,2.15) 16(-2.5,2.15) 17(-3.5,2.15) 18(-4.5,2.15) 19(-5.5,2.15) 20(-6.5,2.15) 21(-7.5,2.15) 22(-8.5,2.15) 23(-9.5,2.15) 24(-10.5,2.15) 25(-11.5,2.15) 26(-12.5,2.15)
  rect 2.21x3.2 smd: 27(14.995,0) 28(-14.995,0)
50675-01001-001
  rect 0.305x1.6 smd: 1(-2.25,0.825) 2(-1.75,0.825) 3(-1.25,0.825) 4(-0.75,0.825) 5(-0.25,0.825) 6(0.25,0.825) 7(0.75,0.825) 8(1.25,0.825) 9(1.75,0.825) 10(2.25,0.825)
  rect 2.007x1.753 smd: 11(-4.5,0) 12(4.5,0)
50696-00601-001
  rect 0.305x0.813 smd: 1(1.25,2.5) 2(0.75,2.5) 3(0.25,2.5) 4(-0.25,2.5) 5(-0.75,2.5) 6(-1.25,2.5)
  rect 0.406x0.813 smd: 7(2.25,0) 8(-2.25,0)
51574-0084N-W01
  rect 0.305x1.194 smd: 1(-3.5,3.3) 2(-2.5,3.3) 3(-1.5,3.3) 4(-0.5,3.3) 5(0.5,3.3) 6(1.5,3.3) 7(2.5,3.3) 8(3.5,3.3)
  rect 0.406x0.813 smd: 9(-5.185,0) 10(5.185,0)
51575-00401-W01
  rect 0.406x0.838 smd: 1(-1.5,3.175) 2(-0.5,3.175) 3(0.5,3.175) 4(1.5,3.175)
  rect 0.813x2.007 smd: 5(-3.7,0) 6(3.7,0)
AFTE14P-75
  round 0.356 smd: 1(0,0)
ARES2H16
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES2H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES8-CN24-MUH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24-UH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24H20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24H22
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
AYF531635
  rect 0.305x0.813 smd: 1(3.75,2.5) 2(3.25,2.5) 3(2.75,2.5) 4(2.25,2.5) 5(1.75,2.5) 6(1.25,2.5) 7(0.75,2.5) 8(0.25,2.5) 9(-0.25,2.5) 10(-0.75,2.5) 11(-1.25,2.5) 12(-1.75,2.5) 13(-2.25,2.5) 14(-2.75,2.5) 15(-3.25,2.5) 16(-3.75,2.5)
  rect 0.406x0.813 smd: 17(4.75,0) 18(-4.75,0)
BGA1356M4224-U2H52
  round 0.356 smd: A3(19.349,-11.314) A70(-19.852,-11.314) B2(19.832,-10.832) B71(-20.314,-10.852) BA1(20.314,10.852) BA71(-20.314,10.852) BB2(19.852,11.314) BB70(-19.852,11.314) C1(20.314,-10.349)
  round 0.33 smd: A4(18.699,-11.314) A69(-19.202,-11.314) AY1(20.314,10.202) AY71(-20.314,10.202) B3(19.197,-10.679) B70(-19.685,-10.685) BA2(19.685,10.685) BA70(-19.685,10.685) BB3(19.202,11.314) BB69(-19.202,11.314) C2(19.679,-10.197) C71(-20.314,-10.202) D1(20.314,-9.699)
  round 0.305 smd: A5(18.048,-11.314) A68(-18.552,-11.314) AA2(19.339,-0.511) AA4(18.363,-0.511) AA63(-15.112,-0.596) AA64(-15.763,-0.596) AA65(-16.413,-0.596) AA66(-17.063,-0.596) AA67(-17.713,-0.596) AA68(-18.364,-0.596) AA69(-19.014,-0.596) AA70(-19.664,-0.596) AA71(-20.314,-0.596) AB4(18.363,0.152) AB6(17.585,-0.133) AB7(16.935,-0.133) AB8(16.285,-0.133) AB9(15.635,-0.133) AB10(14.984,-0.133) AB11(14.334,-0.133) AB12(13.684,-0.133) AB13(13.034,-0.133) AB15(12.188,-0.009) AB16(11.538,-0.009) AB17(10.888,-0.009) AB18(10.237,-0.009) AB19(9.587,-0.009) AB20(8.937,-0.009) AB21(8.287,-0.009) AB62(-14.644,-0.138) AC3(18.689,0.815) AC63(-15.112,0.319) AC64(-15.763,0.319) AC65(-16.413,0.319) AC66(-17.063,0.319) AC67(-17.713,0.319) AC68(-18.364,0.319) AC69(-19.014,0.319) AC70(-19.664,0.319) AC71(-20.314,0.319) AD4(18.363,1.478) AD6(17.585,0.934) AD7(16.935,0.934) AD8(16.285,0.934) AD9(15.635,0.934) AD10(14.984,0.934) AD11(14.334,0.934) AD12(13.684,0.934) AD13(13.034,0.934) AD15(12.188,0.829) AD16(11.538,0.829) AD17(10.888,0.829) AD18(10.237,0.829) AD19(9.587,0.829) AD20(8.937,0.829) AD21(8.287,0.829) AD62(-14.644,0.776) AE62(-14.644,1.69) AE63(-15.112,1.233) AE64(-15.763,1.233) AE65(-16.413,1.233) AE66(-17.063,1.233) AE67(-17.713,1.233) AE68(-18.364,1.233) AE69(-19.014,1.233) AF2(19.339,2.141) AF4(18.363,2.141) AF6(17.585,2.001) AF7(16.935,2.001) AF8(16.285,2.001) AF9(15.635,2.001) AF10(14.984,2.001) AF11(14.334,2.001) AF12(13.684,2.001) AF13(13.034,2.001) AF15(12.188,1.668) AF16(11.538,1.668) AF17(10.888,1.668) AF18(10.237,1.668) AF19(9.587,1.668) AF20(8.937,1.668) AF21(8.287,1.668) AF63(-15.112,2.148) AF64(-15.763,2.148) AF65(-16.413,2.148) AF66(-17.063,2.148) AF67(-17.713,2.148) AF68(-18.364,1.939) AF69(-19.014,1.939) AG4(18.363,2.804) AG15(12.188,2.506) AG16(11.538,2.506) AG17(10.888,2.506) AG18(10.237,2.506) AG19(9.587,2.506) AG20(8.937,2.506) AG21(8.287,2.506) AG62(-14.644,2.605) AG69(-18.689,2.602) AH3(18.689,3.467) AH6(17.585,3.067) AH7(16.935,3.067) AH8(16.285,3.067) AH9(15.635,3.067) AH10(14.984,3.067) AH11(14.334,3.067) AH12(13.684,3.067) AH13(13.034,3.067) AH63(-15.112,3.062) AH64(-15.763,3.062) AH65(-16.413,3.062) AH66(-17.063,3.062) AH67(-17.713,3.062) AJ4(18.363,4.13) AJ15(12.188,3.344) AJ16(11.538,3.344) AJ17(10.888,3.344) AJ18(10.237,3.344) AJ19(9.587,3.344) AJ20(8.937,3.344) AJ21(8.287,3.344) AJ62(-14.644,3.519) AK6(17.585,4.007) AK7(16.935,4.007) AK8(16.285,4.007) AK9(15.635,4.007) AK10(14.984,4.007) AK11(14.334,4.007) AK12(13.684,4.007) AK13(13.034,4.007) AK15(12.188,4.182) AK16(11.538,4.182) AK17(10.888,4.182) AK18(10.237,4.182) AK19(9.587,4.182) AK20(8.937,4.182) AK21(8.287,4.182) AK22(7.596,4.009) AK23(6.681,4.009) AK25(5.767,4.009) AK27(4.852,4.009) AK28(3.938,4.009) AK30(3.024,4.009) AK32(2.109,4.009) AK33(1.195,4.009) AK35(0.28,4.009) AK37(-0.634,4.009) AK38(-1.548,4.009) AK40(-2.463,4.009) AK42(-3.377,4.009) AK43(-4.292,4.009) AK45(-5.206,4.009) AK46(-6.12,4.009) AK48(-7.035,4.009) AK50(-7.949,4.009) AK52(-8.864,4.009) AK53(-9.778,4.009) AK55(-10.692,4.009) AK56(-11.607,4.009) AK58(-12.521,4.009) AK60(-13.436,4.009) AK62(-14.46,4.144) AK63(-15.112,3.976) AK64(-15.763,3.976) AK65(-16.413,3.976) AK66(-17.063,3.976) AK67(-17.713,3.976) AK68(-18.364,3.829) AK69(-19.339,3.829) AL2(19.339,4.793) AL4(18.363,4.793) AL23(7.138,4.474) AL25(6.224,4.474) AL27(5.31,4.474) AL28(4.395,4.474) AL30(3.481,4.474) AL32(2.566,4.474) AL33(1.652,4.474) AL35(0.738,4.474) AL37(-0.177,4.474) AL38(-1.091,4.474) AL40(-2.006,4.474) AL42(-2.92,4.474) AL43(-3.834,4.474) AL45(-4.749,4.474) AL46(-5.663,4.474) AL48(-6.578,4.474) AL50(-7.492,4.474) AL52(-8.406,4.474) AL53(-9.321,4.474) AL55(-10.235,4.474) AL56(-11.15,4.474) AL58(-12.064,4.474) AL60(-12.978,4.474) AL61(-13.893,4.474) AL63(-15.112,4.845) AL64(-15.763,4.845) AL65(-16.413,4.845) AL66(-17.063,4.845) AM4(18.363,5.456) AM5(17.654,4.946) AM7(16.74,4.946) AM8(15.825,4.946) AM10(14.911,4.946) AM11(13.996,4.946) AM13(13.082,4.946) AM15(12.168,4.946) AM16(11.253,4.946) AM18(10.339,4.946) AM20(9.424,4.946) AM21(8.51,4.946) AM22(7.596,4.946) AM23(6.681,4.946) AM25(5.767,4.946) AM27(4.852,4.946) AM28(3.938,4.946) AM30(3.024,4.946) AM32(2.109,4.946) AM33(1.195,4.946) AM35(0.28,4.946) AM37(-0.634,4.946) AM38(-1.548,4.946) AM40(-2.463,4.946) AM42(-3.377,4.946) AM43(-4.292,4.946) AM45(-5.206,4.946) AM46(-6.12,4.946) AM48(-7.035,4.946) AM50(-7.949,4.946) AM52(-8.864,4.946) AM53(-9.778,4.946) AM55(-10.692,4.946) AM56(-11.607,4.946) AM58(-12.521,4.946) AM60(-13.436,4.946) AM61(-14.35,4.946) AM68(-18.039,5.056) AM69(-18.689,5.056) AN3(18.689,6.119) AN5(17.654,5.597) AN7(16.74,5.597) AN8(15.825,5.597) AN10(14.911,5.597) AN11(13.996,5.597) AN13(13.082,5.597) AN15(12.168,5.597) AN16(11.253,5.597) AN18(10.339,5.597) AN20(9.424,5.597) AN21(8.51,5.597) AN22(7.596,5.597) AN23(6.681,5.597) AN25(5.767,5.597) AN27(4.852,5.597) AN28(3.938,5.597) AN30(3.024,5.597) AN32(2.109,5.597) AN33(1.195,5.597) AN35(0.28,5.597) AN37(-0.634,5.597) AN38(-1.548,5.597) AN40(-2.463,5.597) AN42(-3.377,5.597) AN43(-4.292,5.597) AN45(-5.206,5.597) AN46(-6.12,5.597) AN48(-7.035,5.597) AN50(-7.949,5.597) AN52(-8.864,5.597) AN53(-9.778,5.597) AN55(-10.692,5.597) AN56(-11.607,5.597) AN58(-12.521,5.597) AN60(-13.436,5.597) AN61(-14.35,5.597) AN63(-15.264,5.597) AN65(-16.179,5.597) AN66(-17.093,5.597) AN68(-18.364,5.719) AN69(-19.014,5.719) AP4(18.363,6.782) AP5(17.654,6.247) AP7(16.74,6.247) AP8(15.825,6.247) AP10(14.911,6.247) AP11(13.996,6.247) AP13(13.082,6.247) AP15(12.168,6.247) AP16(11.253,6.247) AP18(10.339,6.247) AP20(9.424,6.247) AP21(8.51,6.247) AP22(7.596,6.247) AP23(6.681,6.247) AP25(5.767,6.247) AP27(4.852,6.247) AP28(3.938,6.247) AP30(3.024,6.247) AP32(2.109,6.247) AP33(1.195,6.247) AP35(0.28,6.247) AP37(-0.634,6.247) AP38(-1.548,6.247) AP40(-2.463,6.247) AP42(-3.377,6.247) AP43(-4.292,6.247) AP45(-5.206,6.247) AP46(-6.12,6.247) AP48(-7.035,6.247) AP50(-7.949,6.247) AP52(-8.864,6.247) AP53(-9.778,6.247) AP55(-10.692,6.247) AP56(-11.607,6.247) AP58(-12.521,6.247) AP60(-13.436,6.247) AP61(-14.35,6.247) AP63(-15.264,6.247) AP65(-16.179,6.247) AP66(-17.093,6.247) AP68(-18.039,6.332) AP70(-19.258,6.332) AR5(17.654,6.897) AR7(16.74,6.897) AR8(15.825,6.897) AR10(14.911,6.897) AR11(13.996,6.897) AR13(13.082,6.897) AR15(12.168,6.897) AR16(11.253,6.897) AR18(10.339,6.897) AR20(9.424,6.897) AR21(8.51,6.897) AR22(7.596,6.897) AR23(6.681,6.897) AR25(5.767,6.897) AR27(4.852,6.897) AR28(3.938,6.897) AR30(3.024,6.897) AR32(2.109,6.897) AR33(1.195,6.897) AR35(0.28,6.897) AR37(-0.634,6.897) AR38(-1.548,6.897) AR40(-2.463,6.897) AR42(-3.377,6.897) AR43(-4.292,6.897) AR45(-5.206,6.897) AR46(-6.12,6.897) AR48(-7.035,6.897) AR50(-7.949,6.897) AR52(-8.864,6.897) AR53(-9.778,6.897) AR55(-10.692,6.897) AR56(-11.607,6.897) AR58(-12.521,6.897) AR60(-13.436,6.897) AR61(-14.35,6.897) AR63(-15.264,6.897) AR65(-16.179,6.897) AR66(-17.093,6.897) AR68(-18.364,6.945) AR69(-19.014,6.945) AT2(19.339,7.445) AT4(18.363,7.445) AT5(17.654,7.547) AT7(16.74,7.547) AT8(15.825,7.547) AT10(14.911,7.547) AT11(13.996,7.547) AT13(13.082,7.547) AT15(12.168,7.547) AT16(11.253,7.547) AT18(10.339,7.547) AT20(9.424,7.547) AT21(8.51,7.547) AT22(7.596,7.547) AT23(6.681,7.547) AT25(5.767,7.547) AT27(4.852,7.547) AT28(3.938,7.547) AT30(3.024,7.547) AT32(2.109,7.547) AT33(1.195,7.547) AT35(0.28,7.547) AT37(-0.634,7.547) AT38(-1.548,7.547) AT40(-2.463,7.547) AT42(-3.377,7.547) AT43(-4.292,7.547) AT45(-5.206,7.547) AT46(-6.12,7.547) AT48(-7.035,7.547) AT50(-7.949,7.547) AT52(-8.864,7.547) AT53(-9.778,7.547) AT55(-10.692,7.547) AT56(-11.607,7.547) AT58(-12.521,7.547) AT60(-13.436,7.547) AT61(-14.35,7.547) AT63(-15.264,7.547) AT65(-16.179,7.547) AT66(-17.093,7.547) AT68(-18.039,7.509) AT69(-18.689,7.509) AU4(18.363,8.108) AU5(17.654,8.198) AU7(16.74,8.198) AU8(15.825,8.198) AU10(14.911,8.198) AU11(13.996,8.198) AU13(13.082,8.198) AU15(12.168,8.198) AU16(11.253,8.198) AU18(10.339,8.198) AU20(9.424,8.198) AU21(8.51,8.198) AU22(7.596,8.198) AU23(6.681,8.198) AU25(5.767,8.198) AU27(4.852,8.198) AU28(3.938,8.198) AU30(3.024,8.198) AU32(2.109,8.198) AU33(1.195,8.198) AU35(0.28,8.198) AU37(-0.634,8.198) AU38(-1.548,8.198) AU40(-2.463,8.198) AU42(-3.377,8.198) AU43(-4.292,8.198) AU45(-5.206,8.198) AU46(-6.12,8.198) AU48(-7.035,8.198) AU50(-7.949,8.198) AU52(-8.864,8.198) AU53(-9.778,8.198) AU55(-10.692,8.198) AU56(-11.607,8.198) AU58(-12.521,8.198) AU60(-13.436,8.198) AU61(-14.35,8.198) AU63(-15.264,8.198) AU65(-16.179,8.198) AU66(-17.093,8.198) AV3(18.689,8.799) AV68(-18.029,8.711) AV69(-19.014,8.901) AV70(-19.664,8.901) AW1(20.314,9.551) AW5(17.781,8.911) AW6(17.13,9.038) AW7(16.564,9.363) AW8(15.986,9.038) AW9(15.416,9.363) AW10(14.753,9.038) AW11(14.143,9.363) AW12(13.565,9.038) AW13(12.995,9.363) AW14(12.332,9.038) AW15(11.723,9.363) AW16(11.145,9.038) AW17(10.575,9.363) AW18(9.912,9.038) AW20(9.302,9.363) AW21(8.724,9.038) AW22(8.154,9.363) AW23(7.466,9.038) AW25(6.828,9.363) AW26(6.264,9.038) AW27(5.601,9.363) AW28(4.988,9.038) AW29(4.374,9.363) AW30(3.711,9.038) AW31(3.148,9.363) AW32(2.485,9.038) AW33(1.847,9.363) AW34(1.283,9.038) AW35(0.62,9.363) AW36(0.007,9.038) AW37(-0.607,9.363) AW38(-1.269,9.038) AW39(-1.833,9.363) AW41(-2.471,9.038) AW42(-3.108,9.363) AW43(-3.672,9.038) AW44(-4.335,9.363) AW45(-4.949,9.038) AW46(-5.562,9.363) AW47(-6.163,9.038) AW48(-6.727,9.363) AW49(-7.355,9.038) AW50(-7.984,9.363) AW51(-8.548,9.038) AW52(-9.149,9.363) AW53(-9.762,9.038) AW54(-10.375,9.363) AW55(-11.038,9.038) AW56(-11.602,9.363) AW57(-12.24,9.038) AW59(-12.877,9.363) AW60(-13.441,9.038) AW61(-14.104,9.363) AW62(-14.718,9.038) AW63(-15.331,9.363) AW64(-15.994,9.038) AW65(-16.558,9.363) AW66(-17.093,8.9) AW67(-18.018,9.371) AW68(-18.622,9.622) AW69(-19.267,9.536) AW70(-19.685,10.035) AW71(-20.314,9.551) AY2(19.685,10.034) AY3(19.028,10.028) AY4(18.274,10.043) AY5(17.665,9.689) AY8(15.986,9.689) AY12(13.565,9.689) AY16(11.145,9.689) AY21(8.724,9.689) AY26(6.264,9.689) AY27(5.601,10.014) AY29(4.374,10.014) AY30(3.711,9.689) AY34(1.283,9.689) AY35(0.62,10.014) AY37(-0.607,10.014) AY38(-1.269,9.689) AY43(-3.672,9.689) AY44(-4.335,10.014) AY46(-5.562,10.014) AY47(-6.163,9.689) AY51(-8.548,9.689) AY52(-9.149,10.014) AY54(-10.375,10.014) AY55(-11.038,9.689) AY60(-13.441,9.689) AY61(-14.104,10.014) AY63(-15.331,10.014) AY64(-15.994,9.689) AY66(-17.221,9.689) AY68(-18.535,10.267) B5(18.048,-10.664) B6(17.467,-10.339) B10(14.989,-10.339) B14(12.511,-10.339) B18(10.033,-10.339) B22(7.555,-10.339) B26(5.077,-10.339) B30(2.599,-10.339) B34(0.121,-10.339) B39(-2.357,-10.339) B44(-4.835,-10.339) B48(-7.313,-10.339) B53(-9.791,-10.339) B58(-12.269,-10.339) B62(-14.747,-10.339) B66(-17.226,-10.339) B69(-19.035,-10.685) BA3(19.035,10.685) BA5(17.715,10.626) BA8(15.986,10.339) BA12(13.565,10.339) BA16(11.145,10.339) BA21(8.724,10.339) BA23(7.466,10.258) BA28(4.988,10.258) BA32(2.485,10.258) BA36(0.007,10.258) BA41(-2.471,10.258) BA45(-4.949,10.258) BA49(-7.355,10.339) BA53(-9.762,10.258) BA57(-12.24,10.258) BA62(-14.718,10.258) BA68(-19.035,10.685) BB4(18.551,11.314) BB68(-18.552,11.314) C4(18.615,-10.336) C5(18.048,-10.014) C7(16.791,-10.014) C8(16.228,-10.339) C9(15.664,-10.014) C11(14.313,-10.014) C12(13.75,-10.339) C13(13.186,-10.014) C15(11.835,-10.014) C16(11.272,-10.339) C17(10.708,-10.014) C19(9.357,-10.014) C20(8.794,-10.339) C21(8.23,-10.014) C23(6.879,-10.014) C24(6.316,-10.339) C25(5.752,-10.014) C27(4.401,-10.014) C28(3.838,-10.339) C29(3.274,-10.014) C31(1.923,-10.014) C32(1.36,-10.339) C33(0.796,-10.014) C36(-0.555,-10.014) C37(-1.118,-10.339) C38(-1.682,-10.014) C40(-3.033,-10.014) C41(-3.596,-10.339) C42(-4.16,-10.014) C45(-5.511,-10.014) C46(-6.074,-10.339) C47(-6.638,-10.014) C50(-7.989,-10.014) C51(-8.552,-10.339) C52(-9.116,-10.014) C54(-10.467,-10.014) C55(-11.03,-10.339) C56(-11.594,-10.014) C59(-12.945,-10.014) C60(-13.508,-10.339) C61(-14.072,-10.014) C63(-15.423,-10.014) C64(-15.987,-10.339) C65(-16.55,-10.014) C67(-18.485,-10.299) C68(-18.622,-9.622) C70(-19.685,-10.034) D3(19.339,-9.608) D4(18.691,-9.669) D5(18.09,-9.363) D6(17.441,-9.323) D7(16.791,-9.363) D8(16.228,-9.689) D9(15.664,-9.363) D10(14.989,-9.323) D11(14.313,-9.363) D12(13.75,-9.689) D13(13.186,-9.363) D14(12.511,-9.323) D15(11.835,-9.363) D16(11.272,-9.689) D17(10.708,-9.363) D18(10.033,-9.323) D19(9.357,-9.363) D20(8.794,-9.689) D21(8.23,-9.363) D22(7.555,-9.323) D23(6.879,-9.363) D24(6.316,-9.689) D25(5.752,-9.363) D26(5.077,-9.323) D27(4.401,-9.363) D28(3.838,-9.689) D29(3.274,-9.363) D30(2.599,-9.323) D31(1.923,-9.363) D32(1.36,-9.689) D33(0.796,-9.363) D34(0.121,-9.323) D36(-0.555,-9.363) D37(-1.118,-9.689) D38(-1.682,-9.363) D39(-2.357,-9.323) D40(-3.033,-9.363) D41(-3.596,-9.689) D42(-4.16,-9.363) D44(-4.835,-9.323) D45(-5.511,-9.363) D46(-6.074,-9.689) D47(-6.638,-9.363) D48(-7.313,-9.323) D50(-7.989,-9.363) D51(-8.552,-9.689) D52(-9.116,-9.363) D53(-9.791,-9.323) D54(-10.467,-9.363) D55(-11.03,-9.689) D56(-11.594,-9.363) D58(-12.269,-9.323) D59(-12.945,-9.363) D60(-13.508,-9.689) D61(-14.072,-9.363) D62(-14.747,-9.323) D63(-15.423,-9.363) D64(-15.987,-9.689) D65(-16.55,-9.363) D66(-17.226,-9.323) D67(-17.899,-10.014) D68(-19.267,-9.535) D69(-18.562,-8.971) D71(-20.314,-9.551) E1(20.314,-9.04) E2(19.664,-9.04) E3(19.014,-9.04) E5(17.654,-8.591) E6(16.74,-8.591) E8(15.825,-8.591) E10(14.911,-8.591) E11(13.996,-8.591) E13(13.082,-8.591) E15(12.168,-8.591) E16(11.253,-8.591) E18(10.339,-8.591) E20(9.424,-8.591) E21(8.51,-8.591) E22(7.596,-8.591) E23(6.681,-8.591) E25(5.767,-8.591) E27(4.852,-8.591) E28(3.938,-8.591) E30(3.024,-8.591) E32(2.109,-8.591) E33(1.195,-8.591) E35(0.28,-8.591) E37(-0.634,-8.591) E38(-1.548,-8.591) E40(-2.463,-8.591) E42(-3.377,-8.591) E43(-4.292,-8.591) E45(-5.206,-8.591) E46(-6.12,-8.591) E48(-7.035,-8.591) E50(-7.949,-8.591) E52(-8.864,-8.591) E53(-9.778,-8.591) E55(-10.692,-8.591) E56(-11.607,-8.591) E58(-12.521,-8.591) E60(-13.436,-8.591) E61(-14.35,-8.591) E63(-15.315,-8.655) E65(-16.331,-8.655) E66(-17.347,-8.655) E68(-17.899,-9.363) F2(19.339,-8.466) F4(18.363,-8.466) F5(17.654,-7.941) F6(16.74,-7.941) F8(15.825,-7.941) F10(14.911,-7.941) F11(13.996,-7.941) F13(13.082,-7.941) F15(12.168,-7.941) F16(11.253,-7.941) F18(10.339,-7.941) F20(9.424,-7.941) F21(8.51,-7.941) F22(7.596,-7.941) F23(6.681,-7.941) F25(5.767,-7.941) F27(4.852,-7.941) F28(3.938,-7.941) F30(3.024,-7.941) F32(2.109,-7.941) F33(1.195,-7.941) F35(0.28,-7.941) F37(-0.634,-7.941) F38(-1.548,-7.941) F40(-2.463,-7.941) F42(-3.377,-7.941) F43(-4.292,-7.941) F45(-5.206,-7.941) F46(-6.12,-7.941) F48(-7.035,-7.941) F50(-7.949,-7.941) F52(-8.864,-7.941) F53(-9.778,-7.941) F55(-10.692,-7.941) F56(-11.607,-7.941) F58(-12.521,-7.941) F60(-13.436,-7.941) F61(-14.35,-7.941) F63(-15.315,-8.005) F65(-16.331,-8.005) F66(-17.347,-8.005) F68(-18.562,-8.32) G4(18.363,-7.803) G5(17.654,-7.291) G6(16.74,-7.291) G8(15.825,-7.291) G10(14.911,-7.291) G11(13.996,-7.291) G13(13.082,-7.291) G15(12.168,-7.291) G16(11.253,-7.291) G18(10.339,-7.291) G20(9.424,-7.291) G21(8.51,-7.291) G22(7.596,-7.291) G23(6.681,-7.291) G25(5.767,-7.291) G27(4.852,-7.291) G28(3.938,-7.291) G30(3.024,-7.291) G32(2.109,-7.291) G33(1.195,-7.291) G35(0.28,-7.291) G37(-0.634,-7.291) G38(-1.548,-7.291) G40(-2.463,-7.291) G42(-3.377,-7.291) G43(-4.292,-7.291) G45(-5.206,-7.291) G46(-6.12,-7.291) G48(-7.035,-7.291) G50(-7.949,-7.291) G52(-8.864,-7.291) G53(-9.778,-7.291) G55(-10.692,-7.291) G56(-11.607,-7.291) G58(-12.521,-7.291) G60(-13.436,-7.291) G61(-14.35,-7.291) G63(-15.315,-7.354) G65(-16.331,-7.354) G66(-17.347,-7.354) G68(-18.364,-7.66) G69(-19.014,-7.66) H3(18.689,-7.14) H5(17.654,-6.641) H6(16.74,-6.641) H8(15.825,-6.641) H10(14.911,-6.641) H11(13.996,-6.641) H13(13.082,-6.641) H15(12.168,-6.641) H16(11.253,-6.641) H18(10.339,-6.641) H20(9.424,-6.641) H21(8.51,-6.641) H63(-15.315,-6.704) H65(-16.331,-6.704) H66(-17.347,-6.704) H69(-18.689,-7.096) J4(18.363,-6.477) J5(17.654,-5.99) J6(16.74,-5.99) J8(15.825,-5.99) J10(14.911,-5.99) J11(13.996,-5.99) J13(13.082,-5.99) J22(7.138,-6.827) J23(6.224,-6.827) J25(5.31,-6.827) J27(4.395,-6.827) J28(3.481,-6.827) J30(2.566,-6.827) J32(1.652,-6.827) J33(0.738,-6.827) J35(-0.177,-6.827) J37(-1.091,-6.827) J38(-2.006,-6.827) J40(-2.92,-6.827) J42(-3.834,-6.827) J43(-4.749,-6.827) J45(-5.663,-6.827) J46(-6.578,-6.827) J48(-7.492,-6.827) J50(-8.406,-6.827) J52(-9.321,-6.827) J53(-10.235,-6.827) J55(-11.15,-6.827) J56(-12.064,-6.827) J58(-12.978,-6.827) J60(-13.893,-6.827) J68(-18.362,-6.52) K15(12.188,-5.876) K16(11.538,-5.876) K17(10.888,-5.876) K18(10.237,-5.876) K19(9.587,-5.876) K20(8.937,-5.876) K21(8.287,-5.876) K22(7.596,-6.362) K23(6.681,-6.362) K25(5.767,-6.362) K27(4.852,-6.362) K28(3.938,-6.362) K30(3.024,-6.362) K32(2.109,-6.362) K33(1.195,-6.362) K35(0.28,-6.362) K37(-0.634,-6.362) K38(-1.548,-6.362) K40(-2.463,-6.362) K42(-3.377,-6.362) K43(-4.292,-6.362) K45(-5.206,-6.362) K46(-6.12,-6.362) K48(-7.035,-6.362) K50(-7.949,-6.362) K52(-8.864,-6.362) K53(-9.778,-6.362) K55(-10.692,-6.362) K56(-11.607,-6.362) K58(-12.521,-6.362) K60(-13.436,-6.362) K61(-14.35,-6.362) K63(-15.133,-6.054) K64(-15.783,-6.054) K65(-16.433,-6.054) K66(-17.084,-6.054) K67(-17.734,-6.054) K68(-18.352,-5.846) K70(-19.339,-5.744) L2(19.339,-5.814) L4(18.363,-5.814) L6(17.585,-5.34) L7(16.935,-5.34) L8(16.285,-5.34) L9(15.635,-5.34) L10(14.984,-5.34) L11(14.334,-5.34) L12(13.684,-5.34) L13(13.034,-5.34) L15(12.188,-5.038) L16(11.538,-5.038) L17(10.888,-5.038) L18(10.237,-5.038) L19(9.587,-5.038) L20(8.937,-5.038) L21(8.287,-5.038) L62(-14.644,-5.625) L63(-15.112,-5.168) L64(-15.763,-5.168) L65(-16.413,-5.168) L66(-17.063,-5.168) L67(-17.713,-5.168) L68(-18.364,-5.168) L69(-19.014,-5.168) L70(-19.664,-5.168) L71(-20.314,-5.168) M4(18.363,-5.151) M62(-14.644,-4.71) N3(18.689,-4.488) N6(17.585,-4.4) N7(16.935,-4.4) N8(16.285,-4.4) N9(15.635,-4.4) N10(14.984,-4.4) N11(14.334,-4.4) N12(13.684,-4.4) N13(13.034,-4.4) N15(12.188,-4.2) N16(11.538,-4.2) N17(10.888,-4.2) N18(10.237,-4.2) N19(9.587,-4.2) N20(8.937,-4.2) N21(8.287,-4.2) N63(-15.112,-4.253) N64(-15.763,-4.253) N65(-16.413,-4.253) N66(-17.063,-4.253) N67(-17.713,-4.253) N68(-18.364,-4.253) N69(-19.014,-4.253) N70(-19.664,-4.253) N71(-20.314,-4.253) P4(18.363,-3.825) P15(12.188,-3.362) P16(11.538,-3.362) P17(10.888,-3.362) P18(10.237,-3.362) P19(9.587,-3.362) P20(8.937,-3.362) P21(8.287,-3.362) P62(-14.644,-3.796) R6(17.585,-3.333) R7(16.935,-3.333) R8(16.285,-3.333) R9(15.635,-3.333) R10(14.984,-3.333) R11(14.334,-3.333) R12(13.684,-3.333) R13(13.034,-3.333) R63(-15.112,-3.339) R64(-15.763,-3.339) R65(-16.413,-3.339) R66(-17.063,-3.339) R67(-17.713,-3.339) R68(-18.364,-3.339) R69(-19.014,-3.339) R70(-19.664,-3.339) R71(-20.314,-3.339) T2(19.339,-3.162) T4(18.363,-3.162) T15(12.188,-2.523) T16(11.538,-2.523) T17(10.888,-2.523) T18(10.237,-2.523) T19(9.587,-2.523) T20(8.937,-2.523) T21(8.287,-2.523) T62(-14.644,-2.882) U4(18.363,-2.499) U6(17.585,-2.267) U7(16.935,-2.267) U8(16.285,-2.267) U9(15.635,-2.267) U10(14.984,-2.267) U11(14.334,-2.267) U12(13.684,-2.267) U13(13.034,-2.267) U63(-15.112,-2.424) U64(-15.763,-2.424) U65(-16.413,-2.424) U66(-17.063,-2.424) U67(-17.713,-2.424) U68(-18.364,-2.424) U69(-19.014,-2.424) U70(-19.664,-2.424) U71(-20.314,-2.424) V3(18.689,-1.836) V15(12.188,-1.685) V16(11.538,-1.685) V17(10.888,-1.685) V18(10.237,-1.685) V19(9.587,-1.685) V20(8.937,-1.685) V21(8.287,-1.685) V62(-14.644,-1.967) W4(18.363,-1.173) W6(17.585,-1.2) W7(16.935,-1.2) W8(16.285,-1.2) W9(15.635,-1.2) W10(14.984,-1.2) W11(14.334,-1.2) W12(13.684,-1.2) W13(13.034,-1.2) W63(-15.112,-1.51) W64(-15.763,-1.51) W65(-16.413,-1.51) W66(-17.063,-1.51) W67(-17.713,-1.51) W68(-18.364,-1.51) W69(-19.014,-1.51) W70(-19.664,-1.51) W71(-20.314,-1.51) Y15(12.188,-0.847) Y16(11.538,-0.847) Y17(10.888,-0.847) Y18(10.237,-0.847) Y19(9.587,-0.847) Y20(8.937,-0.847) Y21(8.287,-0.847) Y62(-14.644,-1.053)
  oval 0.254x0.343 smd: A6(17.467,-10.989) A7(16.791,-11.314) A9(15.664,-11.314) A10(14.989,-10.989) A11(14.313,-11.314) A13(13.186,-11.314) A14(12.511,-10.989) A15(11.835,-11.314) A17(10.708,-11.314) A18(10.033,-10.989) A19(9.357,-11.314) A21(8.23,-11.314) A22(7.555,-10.989) A23(6.879,-11.314) A25(5.752,-11.314) A26(5.077,-10.989) A27(4.401,-11.314) A29(3.274,-11.314) A30(2.599,-10.989) A31(1.923,-11.314) A33(0.796,-11.314) A34(0.121,-10.989) A36(-0.555,-11.314) A38(-1.682,-11.314) A39(-2.357,-10.989) A40(-3.033,-11.314) A42(-4.16,-11.314) A44(-4.835,-10.989) A45(-5.511,-11.314) A47(-6.638,-11.314) A48(-7.313,-10.989) A50(-7.989,-11.314) A52(-9.116,-11.314) A53(-9.791,-10.989) A54(-10.467,-11.314) A56(-11.594,-11.314) A58(-12.269,-10.989) A59(-12.945,-11.314) A61(-14.072,-11.314) A62(-14.747,-10.989) A63(-15.423,-11.314) A65(-16.55,-11.314) A66(-17.226,-10.989) A67(-17.901,-11.314) AY7(16.551,10.014) AY9(15.416,10.014) AY11(14.131,10.014) AY13(12.995,10.014) AY15(11.71,10.014) AY17(10.575,10.014) AY20(9.289,10.014) AY22(8.154,10.014) AY25(6.828,10.014) AY31(3.148,10.014) AY33(1.847,10.014) AY39(-1.833,10.014) AY42(-3.108,10.014) AY48(-6.789,10.014) AY50(-7.922,10.014) AY56(-11.602,10.014) AY59(-12.877,10.014) AY65(-16.558,10.014) AY67(-17.901,10.014) B7(16.791,-10.664) B9(15.664,-10.664) B11(14.313,-10.664) B13(13.186,-10.664) B15(11.835,-10.664) B17(10.708,-10.664) B19(9.357,-10.664) B21(8.23,-10.664) B23(6.879,-10.664) B25(5.752,-10.664) B27(4.401,-10.664) B29(3.274,-10.664) B31(1.923,-10.664) B33(0.796,-10.664) B36(-0.555,-10.664) B38(-1.682,-10.664) B40(-3.033,-10.664) B42(-4.16,-10.664) B45(-5.511,-10.664) B47(-6.638,-10.664) B50(-7.989,-10.664) B52(-9.116,-10.664) B54(-10.467,-10.664) B56(-11.594,-10.664) B59(-12.945,-10.664) B61(-14.072,-10.664) B63(-15.423,-10.664) B65(-16.55,-10.664) B67(-17.901,-10.664) BA4(18.366,10.689) BA6(17.173,10.258) BA7(16.61,10.664) BA9(15.416,10.664) BA10(14.753,10.258) BA11(14.189,10.664) BA13(12.995,10.664) BA14(12.332,10.258) BA15(11.768,10.664) BA17(10.575,10.664) BA18(9.912,10.258) BA20(9.348,10.664) BA22(8.154,10.664) BA25(6.828,10.664) BA26(6.165,10.339) BA27(5.502,10.664) BA29(4.473,10.664) BA30(3.811,10.339) BA31(3.148,10.664) BA33(1.847,10.664) BA34(1.184,10.339) BA35(0.521,10.664) BA37(-0.507,10.664) BA38(-1.17,10.339) BA39(-1.833,10.664) BA42(-3.108,10.664) BA43(-3.771,10.339) BA44(-4.434,10.664) BA46(-5.463,10.664) BA47(-6.126,10.339) BA48(-6.789,10.664) BA50(-7.922,10.664) BA51(-8.585,10.339) BA52(-9.248,10.664) BA54(-10.276,10.664) BA55(-10.939,10.339) BA56(-11.602,10.664) BA59(-12.877,10.664) BA60(-13.54,10.339) BA61(-14.203,10.664) BA63(-15.232,10.664) BA64(-15.895,10.339) BA65(-16.558,10.664) BA66(-17.221,10.339) BA67(-17.901,10.664) BB5(17.786,11.314) BB6(17.173,10.989) BB7(16.61,11.314) BB9(15.416,11.314) BB10(14.753,10.989) BB11(14.189,11.314) BB13(12.995,11.314) BB14(12.332,10.989) BB15(11.768,11.314) BB17(10.575,11.314) BB18(9.912,10.989) BB20(9.348,11.314) BB22(8.154,11.314) BB23(7.466,10.908) BB25(6.828,11.314) BB26(6.165,10.989) BB27(5.502,11.314) BB29(4.473,11.314) BB30(3.811,10.989) BB31(3.148,11.314) BB32(2.485,10.908) BB33(1.847,11.314) BB34(1.184,10.989) BB35(0.521,11.314) BB37(-0.507,11.314) BB38(-1.17,10.989) BB39(-1.833,11.314) BB41(-2.471,10.908) BB42(-3.108,11.314) BB43(-3.771,10.989) BB44(-4.434,11.314) BB46(-5.463,11.314) BB47(-6.126,10.989) BB48(-6.789,11.314) BB50(-7.922,11.314) BB51(-8.585,10.989) BB52(-9.248,11.314) BB54(-10.276,11.314) BB55(-10.939,10.989) BB56(-11.602,11.314) BB57(-12.24,10.908) BB59(-12.877,11.314) BB60(-13.54,10.989) BB61(-14.203,11.314) BB63(-15.232,11.314) BB64(-15.895,10.989) BB65(-16.558,11.314) BB66(-17.221,10.989) BB67(-17.901,11.314)
  oval 0.343x0.254 smd: AA1(19.989,-0.511) AB1(20.314,0.152) AB2(19.664,0.152) AB3(19.014,0.152) AC1(19.989,0.815) AC2(19.339,0.815) AD1(20.314,1.478) AD2(19.664,1.478) AD3(19.014,1.478) AF1(19.989,2.141) AF70(-19.664,1.84) AF71(-20.314,1.84) AG1(20.314,2.804) AG2(19.664,2.804) AG3(19.014,2.804) AG70(-19.339,2.503) AG71(-19.989,2.503) AH1(19.989,3.467) AH2(19.339,3.467) AH68(-18.364,3.166) AH69(-19.014,3.166) AH70(-19.664,3.166) AH71(-20.314,3.166) AJ1(20.314,4.13) AJ2(19.664,4.13) AJ3(19.014,4.13) AK70(-19.989,3.829) AL1(19.989,4.793) AL68(-18.364,4.492) AL69(-19.014,4.492) AL70(-19.664,4.492) AL71(-20.314,4.492) AM1(20.314,5.456) AM2(19.664,5.456) AM3(19.014,5.456) AM70(-19.339,5.155) AM71(-19.989,5.155) AN1(19.989,6.119) AN2(19.339,6.119) AN70(-19.664,5.818) AN71(-20.314,5.818) AP1(20.314,6.782) AP2(19.664,6.782) AP3(19.014,6.782) AR70(-19.664,6.846) AR71(-20.314,6.846) AT1(19.989,7.445) AT70(-19.339,7.509) AT71(-19.989,7.509) AU1(20.314,8.108) AU2(19.664,8.108) AU3(19.014,8.108) AU68(-18.364,8.147) AU69(-19.014,8.172) AU70(-19.664,8.172) AU71(-20.314,8.172) AV1(20.314,8.828) AV2(19.364,8.799) AV71(-20.314,8.901) AW2(19.689,9.362) AW3(19.039,9.362) E70(-19.664,-9.009) E71(-20.314,-8.901) F1(19.989,-8.466) F70(-19.212,-8.32) F71(-19.862,-8.384) G1(20.314,-7.803) G2(19.664,-7.803) G3(19.014,-7.803) G70(-19.664,-7.759) G71(-20.314,-7.759) H1(19.989,-7.14) H2(19.339,-7.14) H70(-19.339,-7.096) H71(-19.989,-7.096) J1(20.314,-6.477) J2(19.664,-6.477) J3(19.014,-6.477) J69(-19.014,-6.433) J70(-19.664,-6.433) J71(-20.314,-6.433) K71(-19.989,-5.744) L1(19.989,-5.814) M1(20.314,-5.151) M2(19.664,-5.151) M3(19.014,-5.151) N1(19.989,-4.488) N2(19.339,-4.488) P1(20.314,-3.825) P2(19.664,-3.825) P3(19.014,-3.825) T1(19.989,-3.162) U1(20.314,-2.499) U2(19.664,-2.499) U3(19.014,-2.499) V1(19.989,-1.836) V2(19.339,-1.836) W1(20.314,-1.173) W2(19.664,-1.173) W3(19.014,-1.173)

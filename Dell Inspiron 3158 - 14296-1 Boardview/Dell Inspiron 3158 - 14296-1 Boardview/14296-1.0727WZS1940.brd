# Allegro board 14296-1.0727WZS1940.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCORE_DRVON: length 37.6
  L3 w0.254: v2(45.61,50.38) 45,50.38 44.61,50.77 44.61,54.13 42.45,56.29 42.45,61.77 42.51,61.83 42.51,64.05 40.9,65.65 v2(40.88,65.65)
  L4 w0.254: v2(45.61,50.38) 45.12,50.39 44.1,49.37 39.4,49.37 38.03,48 v2(37.85,48) ; v2(44.36,65.37) 43.67,66.06 41.28,66.06 v2(40.88,65.65)
  BOTTOM w0.203: PU4601.35 37.81,47.95 v2(37.85,48)
  BOTTOM w0.254: PU5002.3 44.23,65.5 v2(44.36,65.37) ; v2(45.61,50.38) 45.04,50.95 45.04,51.64 45.38,51.99 45.78,51.99 v1(46.11,52.32) 46.11,52.95 46.78,53.63 PR4807.2 ; v2(40.88,65.65) 40.74,65.51 PR4703.2
PWR_VCORE_EN: length 3.5
  BOTTOM w0.102: PR4630.1 38.64,45.6 v1(38.48,45.76) 38.47,45.76 37.85,46.38 37.76,46.38 37.24,46.9 PU4601.37
PWR_VCORE_GL: length 3.8
  BOTTOM w0.203: 46.39,60.8 46.39,60.4 ; 46.39,60.8 PU4701.9 ; 46.39,60.8 46.39,61.08 46.26,61.2 PU4701.8 ; 46.39,60.4 46.39,60.17 46.22,60 PU4701.11 ; 46.39,60.4 PU4701.10
PWR_VCORE_ICCMAX: length 4.4
  BOTTOM w0.203: 34.35,54.61 34.35,52.95 34.39,52.91 PU4601.19
  BOTTOM w0.254: PR4658.1 33.66,56.5 v1(33.66,55.67) 33.66,55.3 34.35,54.61
PWR_VCORE_ILIM: length 3.4
  TOP w0.254: v1(38.28,50.82) 38.28,50.87 v2(37.88,51.28) 37.62,51.28 37.12,50.77 PC4633.2 PR4635.1
  BOTTOM w0.203: v2(37.88,51.28) 37.75,51.15 PU4601.27
PWR_VCORE_IOUT: length 3.6
  TOP w0.254: PC4613.2 PR4628.1 37.81,49.74 v2(37.81,49.95) 37.93,49.95 v1(38.34,49.55)
  BOTTOM w0.203: PU4601.30 v2(37.81,49.95)
PWR_VCORE_NTC: length 18.3
  TOP w0.254: v2(31.93,58.72) 32.45,58.2 32.68,58.2 33.12,57.76 33.12,55.8 33.12,55.79 PR4652.1 33.12,54.85 34.12,53.85 PR4650.2
  BOTTOM w0.254: PR4653.2 40.61,63.91 39.62,64.9 38.11,64.9 v1(37.92,64.71) 37.17,63.96 36.67,63.96 35.32,62.61 35.32,62.11 v2(31.93,58.72)
PWR_VCORE_PHASED: length 4.2
  BOTTOM w0.203: PU4701.34 41.4,60.8 ; 41.4,60.8 41.1,61.1 v1(40.59,61.1) ; 41.4,60.8 41.27,60.67 41.27,60.34 41.61,60 PU4701.32
  BOTTOM w0.508: PC4706.2 40.14,61.1 v1(40.59,61.1)
PWR_VCORE_PWM: length 22.5
  L4 w0.508: v2(43.71,64.01) 43.48,63.78 40.98,63.78 40.48,63.28 40.48,61.88 42.07,60.29 42.07,57.12 39.78,54.83 36.22,54.83 35.6,54.21 v2(35.6,53.43)
  BOTTOM w0.203: PU4701.4 44.05,62.75 44.09,62.8 44.09,63.63 v2(43.71,64.01) 43.04,63.33 v1(43.04,63.28) ; PU4601.22 v2(35.6,53.43)
PWR_VCORE_ROSC_COREGT: length 3.5
  BOTTOM w0.203: PU4601.14 32.39,52.98 32.29,53.08 32.29,53.83 32.2,53.91 v1(32.2,53.93)
  BOTTOM w0.254: v1(32.2,53.93) 32.19,53.95 32.19,54.11 31.12,55.17 PR4664.1
PWR_VCORE_ROSC_SAUS: length 3.8
  BOTTOM w0.203: PU4601.15 32.79,53.06 32.7,53.16 32.7,54.49
  BOTTOM w0.254: PR4659.1 31.93,55.34 v1(32.11,55.16) 32.7,54.58 32.7,54.49
PWR_VCORE_SCLK: length 3.6
  BOTTOM w0.114: PU4601.34 37.59,48.35 37.67,48.44 38.03,48.44 38.32,48.16 38.32,47.55 v1(38.31,47.55) 38.34,47.52 38.34,47.2 39.09,46.45 PR4665.2
PWR_VCORE_SDIO: length 2.5
  BOTTOM w0.114: PR4667.2 39.12,48.23 v1(38.31,49.04) 38.2,49.15 PU4601.32
PWR_VCORE_SW: length 3.5
  TOP w0.508: v2(48.17,56.61) v1(49.31,56.61) 49.69,56.61 50.15,57.07 PR4704.1
PWR_VCORE_TSENSE: length 4.5
  TOP w0.254: PC4628.1 34.88,52.53 PR4650.1 ; PC4628.1 35.49,52.61 36.31,53.43 v2(36.35,53.43) ; PC4628.1 34.96,53.43 v1(35.03,53.51)
  BOTTOM w0.203: v2(36.35,53.43) 36,53.08 PU4601.23
PWR_VCORE_VCC: length 5.5
  TOP w0.203: PC4631.1 32.81,52.98 32.71,52.98 32.56,53.13
  TOP w0.508: PR4657.2 31.27,54.2 v2(31.53,53.94) 31.75,53.94 32.56,53.13
  BOTTOM w0.203: v1(31.01,54.51) 31.53,54 v2(31.53,53.94) 31.76,53.71 31.76,53.15 32,52.91 PU4601.13
PWR_VCORE_VCCA: length 4.5
  BOTTOM w0.203: PU4701.6 44.85,62.56 45.12,62.83 45.12,63.4 v1(44.86,63.65) 44.56,63.96 44.56,64.17 PC4708.1
  BOTTOM w0.508: PC4708.1 43.36,64.66 42.87,64.17 PR4702.1
PWR_VCORE_VR_RDY: length 6.1
  BOTTOM w0.203: 36.25,46.2 36,46.45 PU4601.38
  BOTTOM w0.254: PR4670.1 38.19,43.16 37.73,43.63 v1(37.73,43.99) 37.73,45.71 37.24,46.2 36.25,46.2
PWR_VCORE_VRHOT#: length 2.3
  BOTTOM w0.203: PU4601.31 37.52,49.55 37.6,49.47 38.67,49.47
  BOTTOM w0.254: 38.67,49.47 39.02,49.12 PR4668.1
PWR_VCORE_VRMP: length 17.7
  TOP w0.254: PC4629.1 32.06,52.48 30.77,53.78 v2(30.77,53.82)
  BOTTOM w0.203: PU4601.12 31.34,52.88
  BOTTOM w0.254: 31.34,52.88 31.27,52.95 31.27,53.35 30.81,53.82 v2(30.77,53.82) 30.45,54.13 30.45,56.68 30.41,56.72 30.41,57.46 31.16,58.21 v1(31.35,58.21) 34.46,58.21 35.61,57.07 35.87,57.07 36.32,56.62 36.32,55.35 36.5,55.16 37.23,55.16 PR4601.2
PWR_VCORE_VSN: length 4.6
  TOP w0.254: PR4644.2 PC4622.2 37.5,54.32 v2(37.24,54.07)
  BOTTOM w0.203: v2(37.24,54.07) 37.37,53.94 37.37,52.86 37.05,52.55 PU4601.25
  BOTTOM w0.254: v2(37.24,54.07) 37.65,54.07 v1(37.8,53.92)
PWR_VCORE_VSN_R: length 4.5
  TOP w0.254: PR4644.1 35.85,54.9 PC4625.1 ; PR4644.1 PC4622.1 ; PR4644.1 36.61,55.94 v1(35.82,56.73) 35.79,56.73 PR4645.2
PWR_VCORE_VSP: length 5.5
  TOP w0.254: v2(36.35,54.07) 35.59,54.07 34.83,54.83 PR4647.1 PR4669.2
  BOTTOM w0.203: v2(36.35,54.07) 36.48,54.07 36.86,53.69 36.86,53.26 36.39,52.79 PU4601.24
  BOTTOM w0.254: v2(36.35,54.07) 36.35,54.37 v1(36.66,54.68)
PWR_VCORE_VSP_L: length 0.9
  TOP w0.254: PR4669.1 33.88,55.85 PC4627.2
PWR_VCORE_VSP_R: length 4.3
  TOP w0.254: PC4625.2 PR4647.2 34.77,55.85 PC4627.1 34.77,56.86 PR4648.2 33.75,57.44 33.5,57.68 33.5,58.07 33.31,58.26 v1(33.28,58.26)
Q6204_G: length 7.5
  TOP w0.254: v2(123.68,23.74) 123.96,23.46 R6510.2 124.43,24.29 v1(124.34,24.38)
  L3 w0.254: v2(119.92,23.84) 120.02,23.74 v2(123.68,23.74)
  BOTTOM w0.254: v2(123.68,23.74) 123.63,23.74 123.53,23.84 Q6504.2 ; Q6504.5 v2(119.92,23.84)
Q6205_Q: length 5
  TOP w0.381: R6503.2 117.61,19.35 118.55,19.35 v1(118.65,19.25) 118.67,19.27 v2(120.73,19.27)
  BOTTOM w0.381: Q6503.D 120.87,19.49 120.73,19.35 v2(120.73,19.27)
Q6502_D: length 0.6
  TOP w0.381: v1(104.12,25.47) v2(104.12,24.86)
RESET_OUT#: length 183.9
  TOP w0.102: v2(151.8,50.65) 151.74,50.65 151.7,50.69 146.45,50.69 146.22,50.47 KBC24.73 ; v2(104.8,75.59) 104.3,75.09 EC1704.1 v1(102.66,75.09) 100.31,75.09 99.42,74.2 R1706.1
  L4 w0.102: v2(151.8,50.65) 151.74,50.65 151.29,51.1 151.29,54.83 152.86,56.41 152.86,57.58 151.97,58.47 151.97,58.72 151.9,58.8 151.9,60.83 150.53,62.2 148.41,62.2 142.65,67.96 142.65,68.17 142.25,68.57 141.8,68.57 141.75,68.52 139.25,68.52 137.55,70.22 137.55,72.17 134.3,75.42 134.3,79.55 133.86,79.98 133.86,83.32 134.06,83.51 134.06,85.93 134.06,86.38 133.16,87.28 133.16,89.8 133.51,90.15 133.51,95.6 131.48,97.63 131.48,97.88 128.81,100.55 128.4,100.55 127.21,101.75 123.47,101.75 123.32,101.9 118.87,101.9 111.91,94.94 109.73,94.94 105.78,90.99 102.23,90.99 v2(101.89,90.65)
  BOTTOM w0.102: v2(101.89,90.65) 101.89,85.04 101.06,84.22 101.06,79.88 104.8,76.14 v2(104.8,75.59) 104.81,75.59 104.81,67.68 103.13,66.01 103.13,44.12 102.88,43.87 102.88,35.04 103.35,34.58 103.35,33.84 105.91,31.27 105.91,30.27 104.9,29.25 103.48,29.25 102.88,29.86 102.88,31.33 101.8,32.4 100.05,32.4 Q2602.G
REXT: length 2.8
  TOP w0.102: v1(15.06,78.63) R5710.1 15.06,77.15 v2(14.76,76.8)
  BOTTOM w0.102: U5701.18 14.78,76.82 v2(14.76,76.8)
RING2: length 3.8
  TOP w0.203: 18.45,23.34 18.63,23.51 HDA27.31
  TOP w0.508: 18.45,23.34 17.99,22.88 v2(17.99,22.85)
  BOTTOM w0.508: v1(18.79,22.51) 18.78,22.51 ; 18.78,22.51 18.78,22.15 18.54,21.92 R2905.1 ; 18.78,22.51 18.74,22.54 18.66,22.54 18.35,22.85 v2(17.99,22.85)
RING2_R: length 2.1
  BOTTOM w0.508: v1(18.91,21.11) 18.77,21.11 18.69,21.03 R2905.2 17.05,21.03 C2903.1
RING2_R_C: length 3.3
  BOTTOM w0.508: C2903.2 R2906.1 EC2905.1 15.63,23.5 v1(16.47,23.5)
RISING TIME2: length 2.7
  TOP w0.102: U4002.1 61.95,92.3 61.81,92.15 C4016.1 60.79,92.15 v1(60.51,91.87)
RSMRST_PWRGD#: length 10.3
  BOTTOM w0.102: R4029.2 45.24,92.41 45.5,92.16 R4031.2 R4033.2 46.45,92.11 46.84,92.49 R4032.2 50.46,92.31 49.85,91.7 D4002.3 50.53,90.93 v1(51.03,91.42) 51.27,91.67 R4030.2
RSVD_F65: length 2.8
  TOP w0.102: v2(73.22,46.69) 73.22,46.65 72.76,46.19 72.33,46.19 TP612.1
  BOTTOM w0.102: CPU1.F65 72.9,47.09 73.22,46.77 v2(73.22,46.69)
RSVD_G65: length 1.3
  TOP w0.102: TP613.1 72.78,47.18 v2(73.25,47.65)
  BOTTOM w0.102: CPU1.G65 73.55,47.35 v2(73.25,47.65)
RSVD_TP_AK12: length 1.2
  TOP w0.102: TP606.1 84.37,77.56 v2(84.44,77.49)
  BOTTOM w0.102: v2(84.44,77.49) 84.6,77.49 CPU1.AK12
RSVD_TP_AK13: length 2.2
  TOP w0.102: v2(84.44,76.86) 83.86,76.28 83.86,76.05 TP605.1
  BOTTOM w0.102: CPU1.AK13 84.76,76.53 v2(84.44,76.86)
RSVD_TP_AW70: length 5.6
  BOTTOM w0.089: 91.87,39.48 91.69,39.66 91.69,39.74 91.68,39.75 91.68,40.65 91.35,40.97 91.35,41.93 91.36,41.94 91.36,42.51 90.98,42.89 90.98,42.89 90.8,43.06 90.8,43.68 CPU1.AW70
  BOTTOM w0.102: TP615.1 92.01,39.34 91.87,39.48
RSVD_TP_AW71: length 4
  BOTTOM w0.089: TP614.1 91.35,40.73 91.18,40.9 91.18,42.01 91.18,42.01 91.18,42.43 90.91,42.71 90.9,42.71 90.45,43.16 CPU1.AW71
RSVD_TP_BA68: length 9.9
  BOTTOM w0.089: 92.96,40.82 92.94,40.84 92.94,42.68 92.49,43.13 92.29,43.13 91.89,43.53 91.89,44.16 CPU1.BA68
  BOTTOM w0.102: 92.96,40.82 93.57,40.21 97.97,40.21 TP602.1
RSVD_TP_BA70: length 5.6
  BOTTOM w0.089: 92.6,40.47 91.9,41.17 91.9,41.95 91.72,42.14 91.72,42.78 91.44,43.06 91.44,43.21 91.43,43.22 91.43,43.66 CPU1.BA70
  BOTTOM w0.102: 92.6,40.47 93.61,39.46 TP601.1
RSVD_TP_BB68: length 6.7
  BOTTOM w0.102: TP603.1 95.19,40.9 93.83,40.9 93.6,41.13 93.6,43.1 92.52,44.18 92.52,44.42 92.21,44.73 CPU1.BB68
RSVD_TP_BB69: length 7.7
  BOTTOM w0.102: CPU1.BB69 92.21,44.1 92.46,43.85 92.58,43.85 93.25,43.18 93.34,43.09 93.34,41.13 93.77,40.7 96.39,40.7 TP604.1
RTC_AUX_S5: length 173.4
  TOP w0.356: RN1801.2 107.02,91.1 107.33,91.41 107.6,91.41 ; RN1801.1 107.67,91.34 107.6,91.41 ; 108.26,91.57 107.76,91.57 107.6,91.41
  TOP w0.508: R2106.1 103.05,84.38 R1730.1 103.4,85.72 105.63,85.72 108.67,88.76 108.67,91.16 108.26,91.57 108.87,92.18 108.87,93.86 108.4,94.33 106.58,94.33 106.24,94.67 106.24,96.63 106.26,96.66 106.26,98.72 104.81,100.17 v1(104.81,103.42) v2(104.81,104.87) ; R2472.2 158.78,33.78 v2(158.51,33.51)
  L3 w0.508: v2(116.62,106.14) 116.62,106.4 116.99,106.77 124.34,106.77 124.72,106.39 125.9,106.39 126.1,106.6 128.32,106.6 130.89,104.03 133.33,104.03 135.03,102.33 135.03,100.55 136.81,98.77 136.81,97.59 138.54,95.87 138.54,86.56 139.33,85.77 139.33,83.56 140.88,82.01 140.88,79.51 140.7,79.33 140.7,73.04 143.01,70.73 143.01,69.91 141.9,68.8 139.99,68.8 139.61,68.42 139.61,67.74 140.05,67.29 v2(140.44,67.29) 141.5,66.24 141.5,64.98 142.37,64.11 143.73,64.11 144.67,65.05 146.3,65.05 146.87,64.48 146.87,61.81 146.51,61.46 146.51,58.96 148.65,56.82 148.65,55.95 149.87,54.73 149.87,47.45 149.28,46.87 149.28,39.99 146.87,37.57 146.87,36.99 146.87,36.42 144.58,34.12 144.06,34.12 v2(143.92,34.26)
  L4 w0.508: v2(158.51,33.51) 158.4,33.4 158.4,33.23 157.98,32.81 157.29,32.81 156.44,31.96 155.37,31.96 153.81,30.41 151,30.41 150.54,29.94 145.12,29.94 143.84,31.21 143.84,34.18 v2(143.92,34.26) ; v2(104.81,104.87) 105.67,105.73 114.3,105.73 114.71,106.14 v2(116.62,106.14)
  BOTTOM w0.508: D2501.3 139.62,64.86 139.12,65.37 139.12,66.55 139.61,67.04 C2503.1 140.39,67.24 v2(140.44,67.29)
RTC_DET#: length 120.5
  TOP w0.102: v2(111.03,109.31) 111.03,107.18 114.41,103.8 124.39,103.8 126.83,101.36 127.31,101.36 132.37,96.31 132.37,88.77 137.53,83.6 v1(137.53,81.63) 137.42,81.52 137.42,76.75 137.19,76.52 137.19,75.79 137.78,75.2 137.78,72.64 138.79,71.62 139.74,71.62 140.16,71.19 140.16,68.6 139.86,68.29 139.86,66.9 140.43,66.33 Q2505.D ; v2(75.98,89.38) 75.93,89.42 75.93,94.17 78.07,96.31 R2040.2 78.09,97.01 78.09,98.22 v2(78.01,98.29)
  L3 w0.102: v2(80.55,105.81) 80.36,105.81 79.03,104.48 79.03,100.42 77.88,99.28 77.88,98.49 78.01,98.37 v2(78.01,98.29)
  L4 w0.102: v2(80.55,105.81) 80.66,105.71 81.5,105.71 82.18,106.39 82.96,106.39 83.47,105.89 84.74,105.89 86.65,107.79 88.31,107.79 90.06,109.54 101.89,109.54 102.09,109.74 102.72,109.74 102.72,109.75 110.6,109.75 v2(111.03,109.31)
  BOTTOM w0.089: 75.98,86.84 76.17,86.84 76.8,86.21 76.8,85.64 76.96,85.48 76.96,83.98 77.07,83.87 CPU1.P1
  BOTTOM w0.102: 75.98,86.84 75.75,87.06 75.75,89.15 v2(75.98,89.38)
RTC_RST#: length 37.9
  TOP w0.102: v2(100.74,84.83) 100.74,85.64 v1(100.87,85.77) 101.12,85.77 G1801.2 101.57,86.88 EC1807.1 101.85,88 C1806.1 102.41,89.12 103.73,89.12 104.12,88.73 105.2,88.73 105.87,89.4 106.63,89.4 106.74,89.28 RN1801.3 107.02,89.64 106.58,90.08 106.58,91.65 107.98,93.06 Q1802.D
  L3 w0.102: v2(86.17,75.21) 86.6,75.64 89.84,75.64 90.08,75.4 92.28,75.4 93.56,76.68 94.53,76.68 94.64,76.79 96.61,76.79 97.06,77.24 97.06,82.65 98.75,84.35 99.97,84.35 100,84.37 100.29,84.37 v2(100.74,84.83)
  BOTTOM w0.102: v2(86.17,75.21) 86.17,75.08 CPU1.AM16
RTC_X1: length 36.8
  L3 w0.089: v2(86.17,74.3) 86.17,74.65 85.08,75.74 85.08,76.54 85.05,76.57 85.05,79.29 85.37,79.61
  L3 w0.127: v2(88.12,101.06) 88.12,100.61 88.5,100.22 88.5,99.39 88.5,98.92 87.13,97.55 87.13,92.97 88.88,91.22 88.88,88.51 88.65,88.28 88.65,86.81 88.7,86.76 88.7,83.4 88.34,83.04 85.37,80.07 85.37,79.61
  BOTTOM w0.127: X1802.1 92.65,101.56 92.2,102.01 C1804.2 91.64,102.1 91.24,102.1 91.2,102.14 R1815.1 90.77,102.05 v1(89.06,102.05) 88.93,102.05 88.18,101.3 88.18,101.12 v2(88.12,101.06) ; CPU1.AM18 85.85,73.97 v2(86.17,74.3)
RTC_X2: length 38.3
  L3 w0.089: v2(86.17,73.38) 85.76,73.8 85.76,74.67 84.9,75.52 84.9,76.47 84.87,76.5 84.87,80.1
  L3 w0.127: v2(88.75,101.06) 88.75,101.23 88.35,101.63 87.88,101.63 87.55,101.3 87.55,100.05 87.93,99.67 87.93,99.16 86.9,98.12 86.56,97.78 86.56,92.73 87.97,91.33 87.97,89.2 88.08,89.09 88.08,85.67 88.13,85.62 88.13,83.64 84.87,80.38 84.87,80.1
  BOTTOM w0.127: v2(88.75,101.06) 88.79,101.1 v1(89.95,101.1) 90.71,101.1 R1815.2 91.22,101.25 91.24,101.24 91.71,101.24 C1803.2 91.81,101.14 92.09,101.14 92.52,100.71 X1802.4 ; CPU1.AM20 85.85,73.06 v2(86.17,73.38)
RTCRST_ON: length 108.1
  TOP w0.102: v2(148.72,47.57) 148.8,47.49 153.78,47.49 159.24,52.95 159.24,53.01 159.5,53.27 KBC24.31 ; v2(107.63,96.49) 107.63,96.49 107.86,96.49 107.92,96.42 108.49,96.42 EC1808.1 R1816.1 108.97,96.01 Q1802.G
  L3 w0.102: v2(107.63,96.49) 108.03,96.89 108.03,99.02 110.1,101.09 113.19,101.09 113.37,101.26 123.09,101.26 123.24,101.11 126.64,101.11 128,99.75 128.52,99.75 130.59,97.68 130.59,97.27 132.31,95.56 132.65,95.22 132.65,87.26 133.85,86.06 133.85,79.6 133.47,79.22 133.47,75.05 132.98,74.56 132.98,67.82 136.16,64.64 137.03,64.64 138.98,62.68 143.26,62.68 144.79,61.16 144.79,59.78 148.01,56.56 148.01,55.61 149.23,54.39 149.23,48.08 v2(148.72,47.57)
  BOTTOM w0.102: v2(107.63,96.49) 107.17,96.03 v1(107.17,95.93)
RUNPWROK: length 3.3
  TOP w0.102: R2481.2 154.08,57.73 v1(153.2,56.85) 153.2,56.62 152.76,56.17 KBC24.48
SA0_DIMA: length 5.3
  TOP w0.102: R1201.1 v2(125.51,96.11) 125.51,96.23 v1(125.84,96.56)
  BOTTOM w0.102: DIMM1.197 124.95,95.55 v2(125.51,96.11)
SA1_DIMA: length 4.5
  TOP w0.102: v1(124.09,96.39) 124.37,96.11 v2(124.62,96.11) R1202.1
  BOTTOM w0.102: v2(124.62,96.11) 123.98,96.11 123.34,96.75 DIMM1.201
SATA_ACT#: length 6.5
  BOTTOM w0.102: CPU1.H1 73.76,84.23 72.8,85.18 72.8,88.11 TP1601.1 72.68,88.74 R1606.2
SATA_RX_CPU_N0: length 114.4
  L6 w0.102: v2(73.28,73.38) 73.72,73.81 74.6,73.81 75.15,73.26 79.53,73.26 80.14,73.87 81.45,73.87 82.58,72.74 83.14,72.74 84.39,71.49 84.51,71.49 85.42,70.58 85.42,70.47 85.9,69.99 86.44,69.99 86.78,70.33 87.99,70.33 88.17,70.33 89.13,71.29 89.64,71.29 91.79,73.43 91.79,74.83 92.95,75.99 93.34,75.99 93.65,75.99 93.65,75.99 97.22,75.99 97.95,76.71 100.09,76.71 108.49,85.12 108.49,85.67 108.24,85.92 v2(108.24,86.2)
  BOTTOM w0.102: v2(73.28,73.38) 72.96,73.05 CPU1.F20 ; v2(108.24,86.2) 108.24,85.98 108.74,85.47 108.74,84.93 108.39,84.58 108.39,65.44 106.23,63.28 106.23,41.75 109.89,38.09 109.89,31.74 110.31,31.31 110.31,31.3 114.13,27.48 116.15,27.48 116.97,26.67 118.08,26.67 C6006.1
SATA_RX_CPU_P0: length 114.7
  L6 w0.102: v2(72.63,73.38) 73.28,74.03 74.69,74.03 75.24,73.48 79.44,73.48 80.05,74.09 81.54,74.09 82.67,72.95 83.23,72.95 84.48,71.71 84.6,71.71 85.64,70.67 85.64,70.56 85.99,70.21 86.35,70.21 86.69,70.54 88.08,70.54 89.04,71.5 89.55,71.5 91.57,73.52 91.57,74.92 92.86,76.21 93.25,76.21 93.74,76.21 93.74,76.2 97.13,76.2 97.86,76.93 100,76.93 108.27,85.21 108.27,85.58 108.16,85.69 v2(107.86,85.69)
  BOTTOM w0.102: CPU1.E20 72.63,73.25 v2(72.63,73.38) ; v2(107.86,85.69) 108.24,85.69 108.54,85.39 108.54,85.02 108.19,84.66 108.19,65.53 106.03,63.37 106.03,41.67 109.68,38.01 109.68,31.65 110.11,31.23 110.11,31.22 114.05,27.28 116.07,27.28 116.89,26.46 118.1,26.46 C6005.1
SATA_RXN0_R: length 10.5
  BOTTOM w0.102: C6006.2 119.62,26.72 120.73,26.72 120.89,26.88 U6001.7 U6001.4 123.56,26.88 124.09,27.41 124.09,27.54 124.99,28.44 127.68,28.44 127.9,28.22 127.9,27.95 128.05,27.8 HDD1.18
SATA_RXP0_R: length 10.3
  BOTTOM w0.102: HDD1.19 127.55,27.81 127.7,27.96 127.7,28.14 127.6,28.23 125.07,28.23 124.29,27.45 124.29,27.33 123.64,26.68 123.16,26.68 122.88,26.4 U6001.5 U6001.6 120.92,26.4 120.81,26.51 119.71,26.51 C6005.2
SATA_TX_CPU_N0: length 123.5
  L6 w0.102: v2(69.25,72.38) 68.83,72.8 68.83,72.91 69,73.08 70.17,73.08 71.73,71.53 73.05,71.53 73.68,70.9 74.41,70.9 75.2,70.11 81.77,70.11 82.52,69.36 85.51,69.36 85.6,69.27 86.69,69.27 86.89,69.07 88.44,69.07 89.31,69.94 90.36,69.94 91.23,70.82 91.23,71.85 91.31,71.93 91.33,71.95 92.51,73.13 92.51,74.38 92.91,74.77 96.73,74.77 97.01,75.05 98.23,75.05 98.97,75.79 100.25,75.79 109.26,84.8 109.26,86.48 109.37,86.58 v2(109.67,86.58)
  BOTTOM w0.102: v2(69.25,72.38) 69.25,72.07 69.28,72.04 69.32,72 69.96,72 CPU1.B21 ; v2(109.67,86.58) 109.79,86.7 110.01,86.7 110.33,86.39 110.33,85.28 108.9,83.85 108.9,64.56 106.74,62.4 106.74,42.24 110.86,38.12 110.86,34.76 110.4,34.29 110.4,31.95 113.8,28.54 118.59,28.54 C6003.1
SATA_TX_CPU_P0: length 123.5
  L6 w0.102: v2(68.61,72.38) 68.61,73 68.91,73.3 70.26,73.3 71.82,71.74 73.14,71.74 73.77,71.11 74.5,71.11 75.29,70.33 81.86,70.33 82.61,69.58 85.6,69.58 85.69,69.48 86.78,69.48 86.98,69.28 88.35,69.28 89.22,70.16 90.27,70.16 91.01,70.91 91.01,71.94 92.3,73.22 92.3,74.47 92.82,74.99 96.64,74.99 96.92,75.27 98.14,75.27 98.88,76 100.16,76 109.05,84.89 109.05,86.61 v2(109.66,87.22)
  BOTTOM w0.102: CPU1.A21 69.32,71.73 v2(68.61,72.38) ; C6001.1 119.17,28.75 113.88,28.75 110.6,32.03 110.6,34.21 111.07,34.67 111.07,38.2 106.94,42.33 106.94,62.31 109.1,64.47 109.1,83.76 110.53,85.19 110.53,86.47 109.78,87.22 v2(109.66,87.22)
SATA_TXN0_R: length 11.3
  BOTTOM w0.102: C6003.2 120.62,28.42 120.76,28.42 121.25,27.92 U6001.9 U6001.2 122.89,27.92 123.08,28.11 123.31,28.11 124.24,29.05 128.49,29.05 129.2,28.34 129.2,27.96 129.05,27.81 HDD1.16
SATA_TXP0_R: length 11.4
  BOTTOM w0.102: C6001.2 120.29,28.62 120.99,28.62 121.21,28.4 U6001.10 U6001.1 122.98,28.4 123.07,28.31 123.22,28.31 124.16,29.25 128.58,29.25 129.4,28.42 129.4,27.93 129.55,27.78 HDD1.15
SD_RCOMP: length 3.2
  TOP w0.381: R1901.1 80.47,82.43 80.47,80.99 v1(80.5,80.97) 80.5,80.9 81.16,80.24 v2(81.3,80.24)
  BOTTOM w0.305: v2(81.3,80.24) 81.1,80.44 CPU1.AB7
SENSE_PORTA: length 18.7
  TOP w0.254: v2(18.92,34.7) 19.88,34.7 v1(19.97,34.79) 20.1,34.92 ED2906.2 19.73,36.27 19.23,35.78 v2(19.08,35.78)
  L3 w0.254: HPMIC1.5 12.2,33.6 13.04,34.44 16.11,34.44 17.46,35.78 v2(19.08,35.78)
  BOTTOM w0.254: R2924.1 v2(18.92,34.7) ; AFTP2910.1 13.88,32.35 12.63,33.6 HPMIC1.5
SENSOR_I2C_SCL: length 95.8
  TOP w0.114: R2020.2 75.84,88.94 75.8,88.94 75.54,89.19 75.54,94.68 v1(77.04,96.18) 77.62,96.76 77.62,97.35 77.69,97.42 77.69,97.94 77.25,98.38 v2(77.25,98.39) ; v2(87.41,99.31) 87.62,99.09 R6928.2 89.3,98.22 97.74,98.22 98.86,97.1 99.93,97.1 100.05,97.22 RN6901.4 100.14,97.76 101,97.76 101.32,97.43 RN7001.2
  L3 w0.114: v2(48.04,95.47) 48.29,95.73 48.29,96.49 48.13,96.65 46.53,96.65 46.16,97.02 43.93,97.02 43.28,97.66 40.03,97.66 40,97.7 36.98,97.7 36.43,98.26 v2(36.41,98.26)
  L4 w0.114: v2(48.04,95.47) 48.04,95.58 49.7,97.24 58.83,97.24 59.72,96.36 65.69,96.36 66.27,96.94 68.39,96.94 69.1,97.65 72.06,97.65 72.89,98.49 76.39,98.49 76.48,98.39 v2(77.25,98.39)
  BOTTOM w0.114: v2(87.41,99.31) 87.01,98.9 84.7,98.9 82.31,96.51 77.87,96.51 76.81,97.58 76.81,97.95 v2(77.25,98.39) ; LCD1.31 48.55,94.71 48.04,95.22 v2(48.04,95.47) ; v2(36.41,98.26) 36.4,98.27 33.94,98.27 32.67,97 31.85,97 30.6,98.25 HOMBD1.7
SENSOR_I2C_SCL_2G: length 135
  TOP w0.114: v2(163.67,19.27) 163.62,19.22 U7001.1 ; v2(104.99,97.05) 105.32,97.38 v1(105.32,97.76) 105.19,97.88 104.81,97.88 104.35,97.43 RN7001.3
  L4 w0.114: v2(122.59,30.3) 122.99,30.71 126.62,30.71 127.03,31.12 127.35,31.44 127.63,31.44 128.87,31.44 129.24,31.07 129.28,31.02 131.87,31.02 132.12,30.76 133.22,30.76 137.85,30.76 139.3,29.31 139.3,29 139.92,28.39 140.53,28.39 143.03,25.89 146.81,25.89 147.71,26.8 149.72,26.8 150.11,27.19 151.54,27.19 152.09,26.63 153.63,26.63 155.16,28.16 156.86,28.16 156.87,28.15 157.09,28.15 162.06,23.17 162.25,23.17 163.67,21.75 v2(163.67,19.27)
  BOTTOM w0.114: v2(104.99,97.05) 105.43,96.61 105.65,96.61 106.13,96.13 106.13,95.95 108.68,93.4 108.68,89.62 109.93,88.38 110.79,88.38 111.78,87.39 111.78,84.54 110.26,83.03 110.26,52.18 109.91,51.82 109.91,48.16 112.14,45.92 112.14,37.12 113.66,35.6 115.78,35.6 117.29,34.09 117.29,31.06 118.75,29.6 121.89,29.6 v2(122.59,30.3)
SENSOR_I2C_SCL_HUB: length 3.2
  TOP w0.114: v1(87.51,99.94) 88.39,99.94 R6928.1 89.19,100.75 U6901.42
SENSOR_I2C_SDA: length 91.4
  TOP w0.114: v2(77.25,97.76) 77.25,97.25 76.17,96.17 76.17,95.79 75.11,94.74 75.11,91.88 v1(75.03,91.79) R2021.2 ; v2(89.08,99.43) 89.63,98.89 R6929.2 90.12,98.56 97.88,98.56 98.78,97.67 RN6901.3 99.52,97.79 99.52,98.06 99.73,98.27 101.25,98.27 101.43,98.08 RN7001.1
  L3 w0.114: v2(49.18,96.11) 49.18,96.21 48.4,96.99 46.67,96.99 46.3,97.36 44.16,97.36 43.52,98 43.43,98 43.42,98.01 40.24,98.01 40.14,98.1 37.2,98.1 v2(37.05,98.26)
  L4 w0.114: v2(49.18,96.11) 49.92,96.84 58.75,96.84 59.57,96.02 65.83,96.02 66.33,96.52 68.45,96.52 69.24,97.31 72.2,97.31 73.04,98.15 76.25,98.15 76.63,97.76 v2(77.25,97.76)
  BOTTOM w0.114: LCD1.30 49.05,94.84 48.67,95.22 48.67,95.6 v2(49.18,96.11) ; v2(77.25,97.76) 78.15,96.86 82.17,96.86 84.56,99.24 86.59,99.24 87.09,99.74 87.59,99.74 87.74,99.59 88.92,99.59 v2(89.08,99.43) ; v2(37.05,98.26) 36.42,97.63 33.81,97.63 32.84,96.65 31.71,96.65 30.61,97.75 HOMBD1.6
SENSOR_I2C_SDA_2G: length 131.2
  TOP w0.114: U7001.4 162.64,21.86 v2(162.76,21.98) ; RN7001.4 104.52,98.08 104.66,98.23 105.36,98.23 105.68,97.91 105.68,97.1 v2(105.62,97.05)
  L4 w0.114: v2(162.76,21.98) 156.94,27.8 156.72,27.8 156.71,27.81 155.3,27.81 153.78,26.29 151.95,26.29 151.4,26.84 150.25,26.84 149.86,26.45 147.85,26.45 146.95,25.55 142.89,25.55 140.39,28.05 139.77,28.05 138.96,28.86 138.96,29.16 137.88,30.24 132.11,30.24 131.67,30.67 129.13,30.67 128.71,31.09 127.49,31.09 126.75,30.36 123.36,30.36 122.85,29.85 122.38,29.85 v2(121.93,30.3)
  BOTTOM w0.114: v2(105.62,97.05) 105.72,96.96 105.95,96.96 106.48,96.43 106.48,96.09 109.03,93.54 109.03,89.77 110.07,88.72 110.94,88.72 112.12,87.53 112.12,84.4 110.6,82.88 110.6,52.04 110.25,51.68 110.25,48.61 v1(111.2,47.66) 112.49,46.36 112.49,37.25 113.71,36.04 115.83,36.04 117.63,34.23 117.63,31.2 118.83,30.01 121.63,30.01 v2(121.93,30.3)
SENSOR_I2C_SDA_HUB: length 2.2
  TOP w0.114: R6929.1 89.69,99.88 v1(89.69,100.73) U6901.43
SERIRQ: length 123.1
  TOP w0.114: v2(149.97,57.3) 149.96,57.29 KBC24.55 ; v1(98.38,90.14) R1821.2 99.28,89.44 v2(99.09,89.25)
  L3 w0.114: v2(149.97,57.3) 149.07,58.2 149.07,58.25 147.79,59.53 147.79,60.97 148.12,61.3 148.12,66.65 149.18,67.71 149.31,67.71 149.31,67.72 149.71,67.72 149.81,67.61 v2(150.09,67.61) ; v2(99.09,89.25) 98.51,88.67 98.51,86.01 96.16,83.65 96.16,80.07 95.96,79.87 95.96,78.97 94.85,77.87 v2(94.85,77.56)
  L6 w0.102: v2(99.09,89.25) 99.09,93.44 100.84,95.19 102.02,95.19 104.93,98.1 108.22,98.1 108.23,98.1 108.52,98.1 108.8,98.1 115.62,104.92 125,104.92 125.74,105.66 127.43,105.66 127.9,105.66 128.1,105.55 128.32,105.33 128.94,105.05 129.6,104.87 130.48,103.98 131.38,103.98 131.38,103.98 131.48,103.98 132,103.66 132.65,103.01 133.37,103.01 136.61,99.77 136.61,97.68 137.7,96.59 137.7,87.64 138.25,87.1 138.25,84.43 139.35,83.32 139.35,81.1 140.54,79.9 140.54,79.18 141.33,78.4 141.33,77.33 142.94,75.73 142.94,72.96 144.08,71.82 145.38,71.82 146.77,70.43 148.26,70.43 150.12,68.57 150.12,67.65 v2(150.09,67.61)
  BOTTOM w0.089: v2(94.85,77.56) 94.37,78.04 93.32,78.04 93.25,78.12 92.58,78.12 92.43,77.97 92.09,77.97 92.08,77.98 91.26,77.98 CPU1.AY11
SIO_EXT_SCI#: length 5.8
  TOP w0.102: R2411.1 143.43,56.44 143.43,55.71 143.12,55.4 v1(143.12,55.35) 143.12,55.22 143.54,54.81 143.54,53.56 143.84,53.27 KBC24.66
SIO_EXT_SCI#_R: length 146
  TOP w0.102: v2(145.26,55.29) 145.22,55.29 144.51,56 144.51,56.71 144.76,56.97 144.76,58.01 144.57,58.2 R2411.2 ; v1(72.83,90.39) v2(73.44,90.39)
  L3 w0.102: v2(149.38,67.28) 148.48,66.38 148.48,61.14 148.2,60.87 148.2,59.94 v2(148.63,59.51)
  L4 w0.102: v2(148.63,59.51) 146.01,56.89 146.01,56.04 v2(145.26,55.29)
  L6 w0.102: v2(149.38,67.28) 149.38,67.31 147.43,69.26 147.41,69.26 145.2,71.47 143.93,71.47 142.58,72.82 142.58,75.58 140.98,77.19 140.98,78.25 139.63,79.6 139.63,79.77 138.98,80.43 138.98,82.69 138.98,83.19 137.89,84.28 137.89,86.95 137.28,87.56 137.28,89.43 136.54,90.17 136.54,97.25 136.25,97.54 136.25,98.9 131.77,103.38 131.38,103.63 130.33,103.63 129.41,104.55 128.82,104.71 128.69,104.77 128.15,105 127.91,105.24 127.79,105.3 127.29,105.3 125.88,105.3 125.15,104.57 118.09,104.57 111.26,97.75 105.07,97.75 102.16,94.84 101.88,94.84 101.51,94.47 101.51,94.06 99.78,92.33 99.78,89.32 98.92,88.46 98.53,88.46 96.16,86.09 95.14,86.09 92.67,88.56 92.67,88.92 91.37,90.21 89.1,90.21 88.97,90.34 87.74,90.34 87.61,90.21 87.23,90.21 86.65,90.8 86.65,91.93 86.07,92.5 84.67,92.5 84.41,92.25 82.83,92.25 82.52,92.55 80.3,92.55 79.84,93.01 76.69,93.01 74.07,90.39 v2(73.44,90.39)
  BOTTOM w0.089: 74.46,84.46 74.56,84.36 74.56,84.19 74.6,84.1 74.6,84.09 74.6,84.08 74.63,84.02 74.68,83.97 74.68,83.71 74.65,83.63 74.65,83.39 CPU1.J2
  BOTTOM w0.102: 74.46,84.46 73.63,85.29 73.63,87.47 73.89,87.74 73.89,89.19 74.17,89.48 74.17,89.91 73.69,90.39 v2(73.44,90.39) 72.99,90.84 R1608.2
SIO_EXT_SMI#: length 4.5
  TOP w0.102: KBC24.10 161.74,44.87 161.86,44.75 162.22,44.75 R2457.1 R2412.1 v1(164.55,44.18)
SIO_EXT_SMI#_R: length 170.5
  TOP w0.102: R802.1 75.94,81.61 75.94,80.21 76,80.14 76,80.14 v2(76.03,80.12) ; R2412.2 163.19,42.84 162.35,42.84 v2(161.46,43.73)
  L3 w0.102: v2(161.46,43.73) 160.43,44.76 160.43,48.69 158.32,50.8 158.32,51.99 159.93,53.59 159.93,56.32 159.06,57.19 159.06,62.82 156.43,65.45 155.25,65.45 148.1,72.6 148.1,72.74 142.15,78.7 142.15,81.5 140.44,83.2 140.44,86.84 139.48,87.8 139.48,96.84 137.9,98.42 137.9,100.3 133.41,104.79 130.74,104.79 127.43,108.1 125.41,108.1 123.88,108.1 122.99,107.21 115.17,107.21 111.93,110.45 88.66,110.45 88.35,110.76 82.09,110.76 81.35,110.03 79.58,110.03 77.93,108.38 77.93,102.47 76.63,101.17 76.63,100.66 75.3,99.34 75.3,89.44 75.68,89.06 75.68,84.25 76.03,83.9 76.03,80.14 76.03,80.14 v2(76.03,80.12)
  BOTTOM w0.102: v2(76.03,80.12) 76.03,80.14 76.03,80.15 76.03,80.61 CPU1.L6
SIO_EXT_WAKE#: length 145.7
  TOP w0.102: KBC24.116 153.96,40.48 155.33,41.85 155.7,41.85 v2(155.78,41.93) ; v1(84.13,86.81) 84.13,87.64 R2041.2 83.55,87.72 v2(83.29,87.98)
  L3 w0.102: v2(155.78,41.93) 155.78,42.21 155.7,42.29 155.7,50.62 155.49,50.83 155.49,54.96 v2(156.89,56.37)
  L4 w0.102: v2(156.89,56.37) 156.67,56.59 156.67,59.91 153.64,62.94 152.79,62.94 152.29,63.44 152.29,65.01 152.41,65.13 152.41,66.27 149.12,69.56 148.01,69.56 148.01,69.55 147.65,69.55 147.65,69.56 146.22,69.56 144.44,71.34 142.91,71.34 139.22,75.02 v2(139.22,75.91)
  L6 w0.102: v2(83.29,87.98) 84.48,87.98 84.62,88.12 85.91,88.12 86.89,87.14 89.14,87.14 90.1,86.18 92.73,86.18 94.14,84.77 97.82,84.77 99.3,86.25 100.17,86.25 101.96,88.05 101.96,89.76 103.88,91.68 105.34,91.68 106.41,92.74 106.41,93.24 110.04,96.87 111.25,96.87 118.34,103.96 119.36,103.96 129.14,103.96 130.08,103.02 131.2,103.02 135.09,99.21 135.55,98.74 135.55,97.38 135.93,97 135.93,89.92 136.67,89.18 136.67,87.3 137.28,86.7 137.28,84.03 138.37,82.94 138.37,80.17 139.02,79.52 139.02,79.16 138.87,79.01 138.87,76.27 v2(139.22,75.91)
  BOTTOM w0.089: CPU1.AD3 82.74,82.87 82.74,84.16
  BOTTOM w0.102: v2(83.29,87.98) 83.29,87.91 82.74,87.36 82.74,86.01 82.84,85.91 82.84,84.27 82.74,84.16
SIO_PWRBTN#: length 121.7
  TOP w0.102: KBC24.52 151.16,54.05 v2(151.9,53.31) ; R9926.1 105.05,28 105.05,28.15 104.34,28.86 v2(104.34,29.69)
  L3 w0.102: v2(104.34,29.69) 104.43,29.6 107.07,29.6 108.38,30.91 109.86,30.91 110.86,29.91 116.95,29.91 117.72,30.68 121.31,30.68 121.59,30.96 126.43,30.96 130.51,35.05 132.18,35.05 135.37,38.24 135.37,39.06 138.25,41.94 141.78,41.94 v2(143.16,43.33)
  BOTTOM w0.089: CPU1.BA15 91.82,75.53 92.59,75.53 93.15,74.98 93.27,74.98 93.33,74.92 94.63,74.92 94.86,74.69
  BOTTOM w0.102: v2(151.9,53.31) 151.29,52.7 151.29,51.15 149.13,48.99 147.25,48.99 146.84,48.58 146.84,45.08 145.68,43.91 143.75,43.91 v2(143.16,43.33) ; 94.86,74.69 94.9,74.64 96.4,74.64 97.08,73.97 97.08,73.72 97.69,73.1 v1(98.25,73.1) 98.61,73.1 102.93,68.79 102.93,44.21 102.67,43.95 102.67,38.07 101.96,37.36 101.96,35.51 102.86,34.61 102.86,33.49 105.05,31.31 105.05,30.14 104.6,29.69 v2(104.34,29.69)
SIO_RCIN#: length 125.6
  TOP w0.114: KBC24.53 150.76,54.49 150.32,54.04 v2(148.39,54.04) ; v2(96.68,96.61) 98.2,96.61 98.71,96.11 v1(98.71,95.7) 98.71,94.73 R1820.2
  L3 w0.114: v2(148.39,54.04) 148.39,53.42 147.97,53 147.61,53 146.94,53.67 146.94,56.25 144.53,58.66 141.83,58.66 138.78,61.71 137.27,61.71 131.79,67.19 131.79,72.05 131.55,72.28 131.55,83.1 132.42,83.97 132.42,85.3 131.66,86.06 131.66,86.93 131.88,87.15 131.88,94.89 129.83,96.94 129.83,97.13 127.98,98.98 126.82,98.98 126.33,98.48 125.03,98.48 124.52,98.98 124.23,98.98 122.89,100.32 113.75,100.32 111.77,98.34 111.04,98.34 v2(110.48,98.91) ; v2(96.68,96.61) 97.12,96.18 97.12,94.18 94.58,91.64 94.58,88.63 93.92,87.96 93.92,82.32 92.51,80.91 92.51,77.8 91.6,76.89 90.03,76.89 v2(89.66,76.52)
  L4 w0.114: v2(96.68,96.61) 97.9,96.61 99.3,98.02 102.88,98.02 104.27,99.42 109.97,99.42 v2(110.48,98.91)
  BOTTOM w0.114: v2(89.66,76.52) 89.69,76.5 CPU1.AW13
SIO_SLP_A#: length 1.2
  TOP w0.102: v2(86.82,75.21) 87.15,75.54 TP1706.1
  BOTTOM w0.102: CPU1.AN16 86.82,75.08 v2(86.82,75.21)
SIO_SLP_S3#: length 324
  TOP w0.102: KBC24.70 145.72,51.67 146,51.38 147.56,51.38 v2(148.09,51.91) ; v2(37.95,88.92) 38.46,89.43 40.52,89.43 41.12,90.02 R4017.1 R4010.1 41.21,91.38 42.69,91.38 42.99,91.08 44.4,91.08 46.01,92.69 46.01,92.99 46.78,93.75 46.96,93.75 v1(47.94,94.74) 47.94,94.74 48.48,95.28 48.48,96.73 49.6,97.85 51.13,97.85 51.53,98.25 51.53,100.69 51.85,101.01 v2(51.85,101.19)
  L3 w0.102: v2(12.61,73.63) 13.62,72.62 13.62,67.18 13.92,66.88 13.92,64.91 13.82,64.82 13.82,61.59 14.38,61.03 14.38,57.82 13.82,57.26 13.82,55.06 15.65,53.23 15.65,44.16 16.36,43.45 16.36,40.37 17.72,39.01 19.67,39.01 v2(21.24,37.43) ; v2(148.09,51.91) 148.83,52.64 148.83,54.22 147.61,55.44 147.61,56.39 144.38,59.61 144.38,60.99 143.09,62.28 137.5,62.28 132.57,67.21 132.57,72.69 132.2,73.06 132.2,82.48 133.22,83.5 v2(133.22,84.5) 133.22,85.31 132.35,86.18 132.35,86.54 132.44,86.63 132.44,95.14 132.22,95.36 130.39,97.19 130.39,97.53 128.37,99.55 127.92,99.55 127.3,100.17 126.94,100.17 126.28,100.83 123.23,100.83 123,101.06 113.56,101.06 112.8,100.3 110.34,100.3 109.39,99.34 109.39,97.5 108.11,96.23 v2(107.73,95.85) 107.28,95.85 102.7,91.27 102.7,89.05 100.33,86.68 100.31,86.68 96.86,83.23 96.86,77.32 96.53,76.99 94.56,76.99 94.45,76.88 93.45,76.88 93,76.42 90.25,76.42 89.84,76.01 89.48,76.01 89.23,76.26 89.23,76.28 88.95,76.56 87.9,76.56 v2(87.47,76.13) ; v2(103.28,101.06) 102.6,101.75 102.6,107.72 100.45,109.87 86.39,109.87 85.81,110.46 82.2,110.46 81.57,109.82 80.42,109.82 79.91,109.31 v2(79.91,109.19)
  L6 w0.102: v2(76.43,108.63) 76.43,106.7 75.97,106.24 75.97,103.79 72.61,100.42 65.06,100.42 64.62,100.86 60.18,100.86 59.29,101.75 56.88,101.75 56.44,101.31 53.77,101.31 53.46,101.62 52.28,101.62 v2(51.85,101.19) 51.77,101.26 43.38,101.26 42.76,100.64 35.23,100.64 33.04,98.44 32.17,98.44 30.93,97.21 30.31,96.58 27.49,96.58 26.72,95.81 23.53,95.81 19.26,91.55 18.65,91.55 13.42,86.31 13.42,83.62 13.82,83.21 13.82,78.41 13.82,77.5 13.15,76.82 13.15,74.71 13.13,74.69 13.13,74.16 v2(12.61,73.63)
  BOTTOM w0.102: v2(79.91,109.19) 77.76,109.19 77.2,108.63 v2(76.43,108.63) ; CPU1.AP15 87.47,75.99 v2(87.47,76.13) ; PR5305.1 12.73,73.75 v2(12.61,73.63) ; v2(133.22,84.5) 133,84.5 132.51,84 PR5125.1 ; U4004.2 v2(37.95,88.92) ; v2(21.24,37.43) 21.53,37.72 Q4007.G ; v2(107.73,95.85) 107.73,95.86 108.06,96.19 108.06,97.4 105.06,100.4 103.94,100.4 v2(103.28,101.06)
SIO_SLP_S4#: length 210.4
  TOP w0.102: v2(139.35,57.37) 138.71,57.37 134.7,53.36 134.7,49.04 v1(134.4,48.74) v2(133.76,48.1) ; v2(131.22,84.8) 131.99,85.57 133.64,85.57 136.05,83.15 136.05,81.6 135.83,81.39 PR5114.1 ; v2(146,52.73) 145.86,52.87 KBC24.67
  L3 w0.102: v2(92.94,74.2) 93.65,74.9 93.77,74.9 94.15,75.28 94.15,75.4 94.55,75.8 94.55,75.8 94.91,76.17 96.89,76.17 98.67,77.95 98.67,81.13 99.96,82.42 100.74,82.42 102.52,84.19 102.52,87.72 103.43,88.63 104,88.63 104.3,88.33 v2(106.15,88.33) 106.15,88.55 105.92,88.78 105.92,89.15 109.07,92.29 110.4,92.29 115.22,97.11 120.51,97.11 121.41,98.01 124.12,98.01 124.62,97.51 126.8,97.51 127.64,96.67 128.63,96.67 130.86,94.44 130.86,87.51 130.69,87.33 130.69,85.34 v2(131.22,84.8) 131.22,84.64 130.31,83.73 130.31,58.44 131.37,57.37 v2(139.35,57.37) 139.96,56.76 141.25,56.76 141.72,57.23 144.59,57.23 145.97,55.85 145.97,52.76 v2(146,52.73)
  L4 w0.102: v2(61.94,76.74) 63.85,76.74 65.02,77.91 65.02,79.68 66.2,80.87 66.2,82.82 65.89,83.13 65.89,88.92 66.16,89.18 66.16,93.26 67.19,94.28 68.25,94.28 70.06,96.09 73.41,96.09 74.01,96.7 75.85,96.7 76.69,95.85 81.16,95.85 83.78,98.47 87.76,98.47 87.76,98.47 92.5,98.47 96.48,98.47 v2(97.44,97.5)
  BOTTOM w0.102: U4005.2 62.26,74.41 61.7,74.97 61.7,75.35 61.94,75.59 R4023.1 v2(61.94,76.74) ; v2(97.44,97.5) 102.52,97.5 103.81,96.21 103.81,92.78 106.13,90.47 106.13,89.35 105.92,89.15 105.92,88.56 v2(106.15,88.33) ; v2(92.94,74.2) 92.82,74.2 92.37,74.64 CPU1.BA16 ; v2(133.76,48.1) 133.32,47.66 PR5105.1
SIO_SLP_S5#: length 5.8
  BOTTOM w0.089: 92.41,74.91 92.39,74.93 90.87,74.93 CPU1.AY16
  BOTTOM w0.102: 92.41,74.91 92.72,74.6 93.11,74.6 93.17,74.54 93.99,74.54 94.99,73.53 95.57,73.53 TP1703.1
SIO_SLP_SUS#: length 372.5
  TOP w0.102: KBC24.96 143.52,41.27 143.32,41.46 v2(142.79,41.46) ; v2(52.61,101.19) 51.78,100.36 51.78,98.21 51.16,97.59 49.72,97.59 48.75,96.62 48.75,93.44 49.28,92.91 v1(49.28,92.21) 49.28,91.91 49.82,91.38 v2(49.82,89.62) ; R1729.2 v2(110.4,89.5)
  L3 w0.102: v2(142.79,41.46) 142.81,41.47 142.81,42.36 143.59,43.15 143.59,44.39 143.42,44.57 143.42,56.36 143,56.78 141.8,56.78 141.59,56.56 131.9,56.56 130.11,58.35 130.11,87.29 130.54,87.72 130.54,94.21 128.3,96.44 127.57,96.44 126.71,97.3 124.54,97.3 124.04,97.81 121.62,97.81 120.35,96.54 116.69,96.54 114.69,94.53 114.69,93.96 112.7,91.97 112.35,91.97 110.4,90.01 v2(110.4,89.5)
  L4 w0.102: v2(110.4,89.5) 110.4,89.12 103.9,82.62 99.55,82.62 98.79,81.86 98.79,78.91 98.86,78.84 98.86,74.69 99.33,74.21 99.33,71.96 98.28,70.91 96.92,70.91 96.68,71.15 96.68,71.75 96.26,72.16 96.26,72.38 96.01,72.64 95.64,72.64 95.4,72.4 95.4,71.67 94.99,71.26 93.36,71.26 89.87,74.75 85.99,74.75 85.74,74.99 85.74,75.39 85.99,75.64 86.3,75.64 86.78,76.13 v2(86.82,76.13)
  L6 w0.102: v2(49.82,89.62) 52.26,89.62 53.81,91.16 60.37,91.16 61.39,92.18 61.39,92.52 61.39,93.17 63.23,95.02 66.24,95.02 66.7,94.56 68.37,94.56 69.02,95.22 73.71,95.22 74.17,94.75 74.87,94.75 75.39,95.27 83.35,95.27 86.37,98.29 100.48,98.29 102.65,100.46 102.65,101.32 103.26,101.93 v2(103.33,101.93) ; v2(52.61,101.19) 52.18,100.76 51.42,100.76 51.12,101.06 43.47,101.06 42.84,100.44 35.32,100.44 33.12,98.24 32.25,98.24 31.14,97.12 31.14,97.12 30.39,96.38 27.58,96.38 26.81,95.61 23.62,95.61 19.35,91.34 18.74,91.34 13.62,86.23 13.62,83.86 14.03,83.46 14.03,78.5 14.03,77.74 14.33,77.44 14.33,76.63 14.68,76.28 14.68,72 15.84,70.83 15.84,66.72 16.42,66.15 16.42,47.42 18.48,45.35 18.48,42.7 24.72,36.46 24.72,35.89 28.46,32.15 28.93,32.15 29.17,31.92 29.17,30.33 29.55,29.95 29.55,21.43 30.35,20.63 30.35,16.14 33.84,12.64 33.84,9.68 30.26,6.1 v2(30.26,1.49)
  BOTTOM w0.102: v2(110.4,89.5) 110.4,91.73 110.71,92.04 110.71,93.6 109.13,95.18 109.13,96.62 105.15,100.6 104.15,100.6 103.74,101.01 103.74,101.53 v2(103.33,101.93) ; v2(86.82,76.13) 86.82,75.99 CPU1.AN15 ; PR5306.1 30.51,1.75 v2(30.26,1.49) ; PR5215.1 v2(49.82,89.62)
SKTOCC#: length 8.5
  BOTTOM w0.102: TP402.1 66.08,41.12 67.55,42.58 67.6,42.58 67.87,42.85 67.87,43.19 67.6,43.45 67.6,45.91 68.65,46.95 CPU1.A65
SLEEVE: length 17.1
  TOP w0.203: HDA27.30 18.13,23.91 17.56,23.34 v2(17.55,23.34)
  TOP w0.508: R2922.1 17.55,23.34 v2(17.55,23.34)
  L3 w0.508: v2(17.55,23.34) 17.7,23.49 18.35,23.49 19.01,24.15 19.01,26.21 17.94,27.27 17.94,30.19 18.32,30.57 21.5,30.57 21.67,30.42 v2(21.67,30.3)
  BOTTOM w0.254: v1(22.21,30.57) 21.95,30.57 v2(21.67,30.3)
  BOTTOM w0.381: U2901.3 21.66,30.31 v2(21.67,30.3)
SLEEVE_CTRL: length 15
  BOTTOM w0.254: 19.82,31.61 19.82,31.21 19.56,30.96 U2901.5 ; 19.82,31.61 19.82,31.82 20.23,32.23 22,32.23 22.64,31.59 25.94,31.59 v1(26.19,31.84) 27.08,32.73 27.08,34.8 26.33,35.55 25.9,35.55 25.6,35.85 R2915.2 ; 19.82,31.61 U2901.6
SLEEVE_R: length 13.6
  TOP w0.508: R2922.2 15.02,23.34 14.26,24.1 14.26,25.3 14.51,25.56 14.51,27.5 v1(15.68,28.67) 16.97,29.97 16.97,31.06 17.41,31.49 18.47,31.49 18.96,31.97 18.96,32.62 19.11,32.77 C2902.1
SLEEVE_R_C: length 3.3
  TOP w0.508: R2911.1 16.86,34.65 EC2906.1 17.66,33.62 C2902.2 17.86,33.42 v1(17.86,32.35)
SLP_LAN#: length 1.4
  TOP w0.102: v2(89.64,75.21) 90.13,75.21 TP1704.1
  BOTTOM w0.102: CPU1.AW15 90.25,75.21 v2(89.64,75.21)
SM_DRAMRST#: length 90.8
  TOP w0.102: R1204.1 125.76,43.85 ED501.1 125.83,44.61 126.4,45.18 127.54,45.18 127.73,45.37 R1203.2 v2(127.03,45.94) ; v2(97.84,71.6) 97.22,71.6 v1(97.14,71.52)
  L4 w0.102: v2(97.84,71.6) 97.84,71.86 96.85,72.85 95.53,72.85 95.2,72.51 95.2,71.75 94.91,71.46 93.46,71.46 90.84,74.09 90.84,74.93 90.11,75.66 88.59,75.66 v2(88.12,76.12)
  L6 w0.102: v2(127.03,45.94) 128.81,45.94 129.67,46.81 129.67,72.89 129.14,73.42 129.14,78.38 128.56,78.96 126.78,78.96 125.64,80.1 108.4,80.1 103.48,75.19 103.48,74.63 100.16,71.31 98.14,71.31 v2(97.84,71.6)
  BOTTOM w0.102: CPU1.AT13 88.45,76.45 v2(88.12,76.12)
SM_INTRUDER#: length 22.8
  TOP w0.102: R1730.2 101.59,85.37 101.22,85.01 101.22,84.64 100.83,84.25 100.73,84.25 100.73,84.24 v1(100.71,84.24) 100.71,84.25 100.13,84.25 99.7,83.81 v2(99.7,83.48)
  L3 w0.102: v2(99.7,83.48) 99.7,83.23 98.47,82 98.47,78.03 96.82,76.38 94.81,76.38 94.7,76.27 94.69,76.27 93.95,75.53 93.95,75.37 93.68,75.1 93.52,75.1 93.2,74.78 87.91,74.78 v2(87.47,75.21)
  BOTTOM w0.102: CPU1.AP16 87.15,74.89 v2(87.47,75.21)
SM_PGCNTL: length 148.4
  TOP w0.102: v2(119.97,27.2) 119.75,27.2 119.49,27.46 119.49,30.56 117.1,32.94 117.1,39.93 112.36,44.67 103.98,44.67 101.06,41.75 95.79,41.75 94.42,40.38 93.62,40.38 93.06,40.94 93.06,41.64 92.63,42.07 91.98,42.07 90.17,43.89 90.17,44.76 90.61,45.21 91.57,45.21 v2(91.72,45.07) ; v2(132.78,86.36) 132.77,86.35 v1(132.22,86.35)
  L3 w0.102: v2(119.97,27.2) 120.82,26.35 122.63,26.35 123.58,25.4 123.58,24.76 124.71,23.63 128.9,23.63 133.06,27.78 134.25,27.78 134.4,27.93 134.4,29.26 139.47,34.34 139.47,35.06 141.19,36.78 143.17,36.78 146.75,40.35 146.75,42.4 147.15,42.81 147.15,45.68 148.06,46.59 148.06,51.15 149.03,52.11 149.03,54.31 147.81,55.53 147.81,56.47 144.58,59.7 144.58,61.07 143.17,62.48 138.81,62.48 137.03,64.26 136.25,64.26 132.77,67.74 132.77,74.64 133.27,75.14 133.27,79.47 133.65,79.85 133.65,85.49 v2(132.78,86.36)
  BOTTOM w0.089: v2(91.72,45.07) 91.48,45.3 91.31,45.3 91.31,45.3 91.03,45.3 91.03,45.3 90.45,45.3 CPU1.AW67
  BOTTOM w0.102: PR5111.1 132.78,85.73 v2(132.78,86.36)
SM_RCOMP_0: length 2.8
  TOP w0.127: v1(87.14,73.84) 87.25,73.84 87.47,73.61 v2(87.47,73.38)
  TOP w0.254: v2(87.47,73.38) 87.47,73.31 87.97,72.82 88.06,72.82 88.55,72.33 R501.1
  BOTTOM w0.305: v2(87.47,73.38) 87.47,73.52 CPU1.AR18
SM_RCOMP_1: length 3.4
  TOP w0.254: v1(90.35,72.06) 90,72.06 89.76,72.29 R502.1 88.86,72.87 88.54,72.87 88.12,73.29 v2(88.12,73.38)
  BOTTOM w0.305: CPU1.AT18 88.12,73.51 v2(88.12,73.38)
SM_RCOMP_2: length 1.4
  TOP w0.254: R503.1 89.37,73.38 v2(88.77,73.38)
  BOTTOM w0.305: CPU1.AU18 89.1,73.71 v2(88.77,73.38)
SMBCLK1: length 183.3
  TOP w0.114: v2(90.08,24.1) 90.6,23.57 91.22,23.57 91.35,23.44 RN4301.3 ; v2(41.05,6.7) 41.18,6.83 PG4401.2 ; KBC24.9 159.6,44.47 159.49,44.58 159.47,44.58 159.09,44.95 v2(159.09,44.97) ; v2(56.67,16.73) 56.69,16.73 57.13,16.29 58.65,16.29 v1(58.78,16.43) 66.89,16.43 69.06,18.6 69.06,22.84 71.32,25.09 74,25.09 79.01,30.1 81.09,30.1 82.2,28.99 v2(82.2,28.8) ; v2(140.24,29.25) 140.01,29.25 139.03,30.24 RN2402.3
  L3 w0.114: v2(160.08,30.12) 160.49,30.53 160.49,33.11 160.59,33.22 160.59,34.66 160.78,34.84 160.78,43.26 159.61,44.43 159.61,44.46 159.35,44.72 159.32,44.72 159.09,44.94 v2(159.09,44.97) ; v2(41.05,6.7) 41.62,7.27 43.05,7.27 45.04,9.26 45.75,9.26 46.47,9.98 46.47,12.43 46.04,12.86 46.03,12.86 46,12.89 45.89,12.89 45.44,13.34 45.44,13.99 46.08,14.63 46.29,14.63 46.58,14.92 46.58,14.94 48.58,16.94 55.1,16.94 55.28,16.76 56.64,16.76 v2(56.67,16.73)
  L4 w0.114: v2(160.08,30.12) 159.65,30.12 158.82,29.29 155.34,29.29 153.91,27.86 150.67,27.86 150.67,27.86 149.83,27.86 149.44,27.47 147.29,27.47 146.43,26.61 143.26,26.61 140.81,29.06 140.6,29.06 140.4,29.25 v2(140.24,29.25) 140.24,29.32 139.81,29.75 139.81,29.76 138.14,31.43 132.4,31.43 132.14,31.69 131.61,31.69 131.61,31.69 130.96,31.69 130.96,31.69 129.64,31.69 129.1,32.23 127.19,32.23 126.37,31.41 125.17,31.41 124.26,32.32 123.83,32.32 122.92,31.42 120.4,31.42 114.85,25.87 114.85,25.34 114.44,24.93 111.44,24.93 111.08,24.57 107.87,24.57 107.26,23.96 106.61,23.96 105.15,25.43 95.21,25.43 86.09,25.43 83.16,28.36 82.7,28.36 82.26,28.8 v2(82.2,28.8)
  BOTTOM w0.114: PR4432.2 41.05,6.25 v2(41.05,6.7) ; v2(82.2,28.8) 82.71,28.29 83.73,28.29 85.03,29.59 87.15,29.59 87.94,28.8 88.74,28.8 EC4305.1 88.93,28.61 D4303.3 89.41,25.14 90.08,24.48 v2(90.08,24.1)
SMBCLK2: length 42.9
  TOP w0.114: Q2604.3 144.19,68.37 144.65,67.91 RN2603.4 145.38,67.48 v2(145.45,67.4) 146.23,66.62 R2459.1 ; v2(150.15,46.2) 150.8,46.85 154.12,46.85 155.99,48.73 156.93,48.73 157.22,48.73 158.6,47.35 158.6,47.01 159.35,46.27 159.35,45.9 159.58,45.67 KBC24.12
  L3 w0.114: v2(150.15,46.2) 150.58,46.63 150.58,48.87 150.41,49.05 150.41,55.76 149.19,56.98 149.19,57.04 147.05,59.18 147.05,61.23 147.41,61.59 147.41,65.17 146.41,66.16 145.43,66.16 145.01,66.59 145.01,66.97 v2(145.45,67.4)
  BOTTOM w0.114: v2(150.15,46.2) 150.2,46.15 v1(150.7,46.15)
SMBDA1: length 189.2
  TOP w0.114: v2(159.16,44.27) 159.18,44.27 159.38,44.07 KBC24.8 ; RN4301.2 91.85,23.56 91.49,23.91 91.29,23.91 91.29,23.92 90.89,23.92 v2(90.71,24.1) ; RN2402.4 139.68,30.5 v2(140.25,29.93) ; v2(82.88,28.8) 82.35,29.33 82.35,29.33 81.23,30.45 78.87,30.45 73.86,25.44 71.18,25.44 68.72,22.98 68.72,18.74 66.89,16.91 57.48,16.91 v2(57.31,16.73) ; v2(40.29,6.7) 40.16,6.83 PG4408.2
  L3 w0.114: v2(82.88,28.8) 82.96,28.8 87.18,24.58 90.23,24.58 v2(90.71,24.1) ; v2(160.05,30.77) 160.05,32.6 160.15,32.7 160.15,33.25 160.25,33.36 160.25,34 159.9,34.35 159.9,36.78 160.34,37.21 160.34,43.07 159.17,44.23 159.17,44.26 v2(159.16,44.27) ; v2(40.29,6.7) 41.26,7.66 42.91,7.66 44.86,9.62 45.23,9.62 45.24,9.61 45.61,9.61 46.13,10.12 46.13,12.29 45.9,12.52 45.88,12.52 45.86,12.55 45.75,12.55 45.1,13.2 45.1,13.63 45.1,14.13 45.94,14.97 46.13,14.97 48.44,17.29 55.25,17.29 55.35,17.18 56.84,17.18 57.29,16.73 v2(57.31,16.73)
  L4 w0.114: v2(160.05,30.77) 159.81,30.77 158.68,29.63 155.2,29.63 153.77,28.2 150.81,28.2 149.69,28.2 149.3,27.81 147.15,27.81 146.29,26.95 143.41,26.95 140.95,29.41 140.77,29.41 v2(140.25,29.93) 140.21,29.93 140.12,29.93 138.28,31.77 132.55,31.77 132.28,32.04 131.47,32.04 131.47,32.03 131.11,32.03 131.11,32.04 129.78,32.04 129.24,32.58 128.56,32.58 127.57,32.58 126.38,33.76 124.89,33.76 123.79,32.66 123.68,32.66 122.88,31.86 120.35,31.86 116.42,27.94 113.6,27.94 111.49,25.83 106.68,25.83 106.63,25.77 87.06,25.77 86.23,25.77 83.3,28.7 83.29,28.7 83.19,28.8 v2(82.88,28.8)
  BOTTOM w0.114: v2(40.29,6.7) 40.29,6.3 39.48,5.49 PR4414.2 ; EC4306.1 91.4,29.24 87.99,29.24 87.29,29.93 84.66,29.93 v1(83.52,28.8) v2(82.88,28.8) ; D4302.3 91.24,25.14 90.71,24.61 v2(90.71,24.1)
SMBDA2: length 48.5
  TOP w0.114: KBC24.11 159.75,45.27 159.7,45.32 159.37,45.32 159.28,45.41 159.25,45.41 159.03,45.63 158.73,45.63 158.26,46.1 158.26,47.2 157.07,48.38 156.14,48.38 154.26,46.51 151.09,46.51 v2(150.15,45.56) ; R2447.1 145.76,66.08 145.76,66.46 v2(145.45,66.77) 145.39,66.83 RN2603.3 144.18,66.83 144.05,66.95 144.05,67.66 143.67,68.04 142.78,68.04 142.56,68.26 142.56,68.26 142.24,68.58 141.49,68.58 140.77,69.3 140.77,69.89 v1(141.23,70.35) 141.89,71.01 Q2604.6
  L3 w0.114: v2(150.15,45.56) 150.93,46.34 150.93,49.01 150.75,49.19 150.75,55.9 149.53,57.12 149.53,57.18 147.39,59.32 147.39,61.09 147.75,61.45 147.75,65.39 146.57,66.57 145.65,66.57 v2(145.45,66.77)
SML0_SMBCLK: length 8.6
  TOP w0.114: v2(78.09,78.85) 77.99,78.85 77.63,79.22 77.63,83.67 76.87,84.43 v1(76.87,84.8) 76.87,85.18 77.24,85.55 RN1807.5
  BOTTOM w0.114: v2(78.09,78.85) 77.85,78.85 CPU1.R9
SML0_SMBDATA: length 5.3
  TOP w0.114: RN1807.6 77.89,85.63 78.29,85.22 79.11,85.22 v1(79.25,85.08) 79.77,85.08 v2(79.91,85.23)
  BOTTOM w0.089: v2(79.91,85.23) 80.12,85.03 80.12,84.97 80.32,84.76 80.32,84.32 80.08,84.08 80.08,83.75 79.73,83.4 CPU1.W2
SML1_SMBCLK: length 125.1
  TOP w0.114: v2(146.23,63.75) 146.23,63.95 146.23,63.95 R2459.2 ; v2(102.14,94.2) 102.16,94.19 Q2601.3 ; RN1807.7 78.39,85.7 78.52,85.57 79.25,85.57 79.26,85.58 79.42,85.58 79.71,85.87 v2(79.92,85.87) ; Q2604.4 144.19,71.76 144.05,71.9 v1(141.41,71.9) v2(140.27,71.9)
  L3 w0.114: v2(146.23,63.75) 146.23,63.2 145.88,62.85 145.1,62.85 144.73,63.22 141.91,63.22 140.54,64.6 140.54,65.56 139.79,66.3 139.39,66.3 138.52,67.18 138.52,68.89 140.27,70.64 v2(140.27,71.9) 139.44,72.73 139.44,74.05 136.46,77.03 136.46,81.52 134.82,83.16 134.82,87.11 133.84,88.09 133.84,89.72 133.62,89.93 133.62,95.66 131.57,97.72 131.57,98.08 128.93,100.72 128.4,100.72 127.05,102.08 123.64,102.08 123.49,102.23 112.97,102.23 112.79,102.06 109.38,102.06 102.14,94.82 v2(102.14,94.2)
  L4 w0.114: v2(87.43,90.65) 87.4,90.68 86.56,90.68 84.11,88.22 84.11,83.81 83.61,83.32 82.54,83.32 81.87,83.99 81.87,85.37 81,86.24 80.29,86.24 v2(79.92,85.87) ; v2(93.8,92.33) 93.96,92.33 94.43,92.8 100.73,92.8 v2(102.14,94.2)
  L6 w0.102: v2(93.8,92.33) 93.8,91.86 93.57,91.63 92.91,91.63 91.93,90.65 v2(87.43,90.65)
  BOTTOM w0.089: v2(79.92,85.87) 79.47,85.41 79.47,83.71 79.49,83.63 79.51,83.62 79.51,83.36 79.51,83.36 79.45,83.24 79.45,83.1 79.51,82.96 79.51,82.79 79.68,82.57 CPU1.W3
SML1_SMBDATA: length 122.6
  TOP w0.114: Q2601.6 100.85,94.22 v2(100.87,94.2) ; RN1807.8 79.34,86.1 v2(79.75,86.5) 79.77,86.48 v1(80.32,86.48) ; Q2604.1 142.59,69.44 v2(141.26,69.44) ; R2447.2 145.41,64.41 145.65,64.17 v2(145.65,64.02)
  L3 w0.114: v2(145.65,64.02) 145.2,63.57 142.06,63.57 140.88,64.74 140.88,65.7 139.93,66.65 139.54,66.65 138.86,67.32 138.86,68.75 139.48,69.37 141.19,69.37 v2(141.26,69.44) 141.26,69.78 140.69,70.34 140.69,71.71 140.7,71.72 140.7,72.16 139.86,73.01 139.86,74.64 136.8,77.7 136.8,81.66 135.18,83.29 135.18,89.1 133.97,90.32 133.97,95.81 131.91,97.86 131.91,98.23 129.07,101.07 128.55,101.07 127.19,102.43 123.78,102.43 123.63,102.58 112.83,102.58 112.65,102.4 109.07,102.4 v2(100.87,94.2)
  L4 w0.114: v2(79.75,86.5) 80,86.5 80.08,86.58 81.15,86.58 82.21,85.52 82.21,84.13 82.69,83.66 83.47,83.66 83.76,83.95 83.76,88.08 83.76,88.08 83.76,88.36 86.56,91.15 87.26,91.15 v2(87.38,91.28) ; v2(93.18,92.13) 93.18,92.7 93.63,93.14 99.81,93.14 v2(100.87,94.2)
  L6 w0.102: v2(87.38,91.28) 87.64,91.28 87.92,91 91.68,91 92.81,92.13 v2(93.18,92.13)
  BOTTOM w0.089: CPU1.V3 79.32,82.45 79.32,82.93 79.28,83.05 79.28,83.06 79.28,83.28 79.32,83.38 79.32,83.58 79.28,83.7 79.28,83.71 79.26,83.75 79.26,86.01 79.39,86.14
  BOTTOM w0.114: 79.39,86.14 v2(79.75,86.5)
SPDIF_TP: length 4.3
  TOP w0.102: TP2702.1 28.26,24.82 27.53,24.82 27.33,24.96 25.58,24.96 25.43,25.11 HDA27.6
SPI0_MOSI_XDP: length 75.4
  TOP w0.114: v2(96.3,88.74) 96.23,88.8 R1826.1 ; C9903.1 R9909.2 108.74,29.96 108.93,30.14 108.93,30.56 108.8,30.69 XDP1.47 108.8,33.81 v2(108.87,33.88)
  L4 w0.114: v2(96.3,88.74) 96.74,88.3 98.29,88.3 98.62,87.97 101.16,87.97 101.89,88.7 105.43,88.7 105.7,88.97 v2(106.36,88.97)
  BOTTOM w0.114: v2(106.36,88.97) 106.84,88.49 v1(106.84,87.9) 106.84,83.34 107.6,82.58 107.6,65.75 105.51,63.66 105.51,43.18 105.16,42.82 105.16,41.68 108.79,38.04 108.79,36.19 108.87,36.12 v2(108.87,33.88)
SPI1_CLK_ROM_R: length 14.9
  TOP w0.114: v1(135.19,98.27) 135.19,98.49 v2(134.91,98.77) 134.86,98.82 134.84,98.82 134.45,99.21 133.9,99.21 R2511.1
  BOTTOM w0.114: SKT252.6 136.73,96.18 136.94,95.98 137.32,95.98 137.45,96.11 137.45,98.24 137.32,98.37 135.52,98.37 135.39,98.49 135.39,98.75 135.52,98.88 137.11,98.88 137.24,99 137.24,100.04 136.98,100.3 136.75,100.3 EC2505.1 136.22,99.85 135.77,99.4 135.48,99.4 134.91,98.82 v2(134.91,98.77)
SPI1_HOLD_ROM_R: length 21.6
  TOP w0.114: R2509.1 123.03,105.82 v2(123.35,105.5) v1(123.35,104.95)
  BOTTOM w0.114: SKT252.7 SPI252.7 138,98.29 137.61,98.69 137.61,100.43 135.51,102.53 130.32,102.53 130,102.84 130,103.1 129.32,103.78 127.37,103.78 127.29,103.7 125.66,103.7 123.85,105.5 v2(123.35,105.5)
SPI1_SI_ROM_R: length 12.8
  BOTTOM w0.114: SKT252.5 135.46,95.88 135.34,95.75 135.01,95.75 134.88,95.88 134.88,95.93 134.75,96.06 134.36,96.06 134.22,96.2 134.22,96.46 134.35,96.59 134.75,96.59 134.88,96.72 134.88,96.97 134.75,97.1 133.32,97.1 133.18,97.24 133.18,97.55 133.31,97.68 134.63,97.68 134.75,97.81 134.75,98.16 134.63,98.29 133.31,98.29 133.18,98.42 133.18,98.7 133.31,98.82 133.48,98.82 v1(133.61,98.95) 133.61,98.98 133.74,99.1 EC2506.1 R2512.1

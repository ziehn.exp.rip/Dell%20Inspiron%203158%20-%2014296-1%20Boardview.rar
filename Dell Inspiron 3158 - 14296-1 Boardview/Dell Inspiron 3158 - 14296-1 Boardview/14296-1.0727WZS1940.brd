# Allegro board 14296-1.0727WZS1940.brd (continued)
## Nets (continued)
DCBATOUT: EC8905.1 EC8906.1 EC8907.1 EC8908.1 EC8926.1 EC8927.1 EC8928.1 EC8929.1 EC8930.1 EC8931.1 EC8932.1 F5503.2 PC4403.1 PC4408.1 PC4409.1 PC4430.1 PC4441.1 PC4442.1 PC4509.1 PC4511.1 PC4512.1 PC4513.1 PC4515.1 PC4522.1 PC4701.1 PC4702.1 PC4703.1 PC4704.1 PC4705.1 PC4710.1 PC4802.1 PC4803.1 PC4804.1 PC4805.1 PC4806.1 PC4810.1 PC5002.1 PC5003.1 PC5004.1 PC5106.1 PC5107.1 PC5108.1 PC5214.1 PC5215.1 PC5216.1 PG4407.2 PL4401.2 PR4443.1 PR4601.1 PT4702.1 PT4803.1 PU4501.2 PU4502.2 PU4503.12 PU4701.25 PU4701.26 PU4701.27 PU4701.28 PU4701.29 PU4701.30 PU4803.25 PU4803.26 PU4803.27 PU4803.28 PU4803.29 PU4803.30 PU5001.5 PU5001.6 PU5001.7 PU5001.8 PU5101.8 PU5202.8 R5514.2
DCBATOUT_LCD: C5512.1 C5513.1 C5514.1 F5503.1 LCD1.1 LCD1.2 LCD1.3 LCD1.4 R5514.1
DCIN_EN: R5419.2 U5701.13
DDC_CLK_HDMI: HDMI1.15 R5707.2 U5701.32
DDC_CLK_PH1: D5701.2 R5707.1
DDC_DATA_HDMI: HDMI1.16 R5706.2 U5701.33
DDC_DATA_PH2: D5701.1 R5706.1
DDCBUF: R5417.2 R5418.2 U5701.14
DDR0_PAR: CPU1.AT52 TP501.1
DDR1_PAR: CPU1.AP43 TP502.1
DDR3_DRAMRST#: DIMM1.30 ED1217.1 R1204.2
DDR_VREF_S3: PC5116.1 PU5102.6 R4204.1 R4210.1
DMIC_CLK: EC5504.1 R2716.2 R5504.2
DMIC_CLK_C: LCD1.18 R5504.1
DMIC_CLK_R: HDA27.10 R2716.1
DMIC_DATA: EC5503.1 R2714.2 R5505.2
DMIC_DATA_C: LCD1.19 R5505.1
DMIC_DATA_R: EC2701.1 HDA27.8 R2714.1
DS3_PWRCTL: R4102.2 U4101.4
E51_TXD_R: DB3.5 JTAG1.8 R2467.1 R2482.1
E71_TP: CPU1.E71 TP2313.1
EAPD#: HDA27.11 R2704.1 R2723.2
EC5048_TX: JTAG1.9 R2453.2
EC_AGND: C2408.1 C2422.2 C2427.2 C2435.2 C2441.2 KBC24.112 R2444.2 R2445.2
EC_MUTE#: KBC24.119 R2704.2
EC_SPI_CLK: KBC24.32 R2485.2
EC_SPI_CS0#: KBC24.27 R2490.2 R2491.2
EC_SPI_MISO: KBC24.29 R2487.2
EC_SPI_MOSI: KBC24.28 R2486.2
EC_VTT: C2406.1 KBC24.95 R2402.2 R2440.2 R2492.2
EC_WAKE#: KBC24.35 R1732.1
ECVBAT: C2428.1 KBC24.122 R2451.2 R2472.1 R2496.2
EDP_AUX: C5510.1 LCD1.12
EDP_AUX#: C5511.1 LCD1.13
EDP_AUX_DN: C5511.2 CPU1.E45
EDP_AUX_DP: C5510.2 CPU1.F45
EDP_COMP: CPU1.E52 R801.2
EDP_DISP_UTIL: CPU1.B52 TP801.1
EDP_HPD: CPU1.L10 R5506.2 RN5502.7(B)
EDP_HPD_CONN: LCD1.24 R5506.1
EDP_TX0: C5509.1 LCD1.10
EDP_TX0#: C5506.1 LCD1.9
EDP_TX0_DN: C5506.2 CPU1.C47
EDP_TX0_DP: C5509.2 CPU1.C46
EDP_TX1: C5504.1 LCD1.7
EDP_TX1#: C5501.1 LCD1.6
EDP_TX1_DN: C5501.2 CPU1.D46
EDP_TX1_DP: C5504.2 CPU1.C45
EDP_VDD_EN: CPU1.U13 D5501.1
EDRAM_OPIO_RCOMP: CPU1.H66 R414.1
EMMC_RCOMP: CPU1.AT1 R1502.1
EOPIO_RCOMP: CPU1.H65 R415.1
EQ: R5411.2 R5412.2 U5701.17
EXT_PWR_GATE#: CPU1.AM10 R1731.2 R1733.1
FALL_INT2: Q7001.2 Q7001.3 R7018.2
FAN1_PWM: KBC24.47 R2614.1
FAN1_TACH: D2403.A KBC24.40 R2430.1
FAN_PWM1_C: AFTP2602.1 FAN1.4 R2614.2
FAN_TACH1: D2403.K R2613.1
FAN_TACH1_C: AFTP2601.1 FAN1.3 R2613.2
FAN_VCC_1: AFTP2603.1 C2603.1 C2604.1 C2605.1 D2601.K FAN1.1 R2612.2
FFS_INT1_D: R7015.1 U7002.12
FFS_INT2: CPU1.AC2 D7001.3 R2044.2 R7008.2
FFS_INT2_D: R7017.1 U7002.11
FFS_INT2_Q: Q7001.6 R6001.1
FFS_INT2_Q_R: HDD1.1 R6001.2
FFS_SCL: R7014.2 U7002.1
FFS_SDA: R7016.2 U7002.4
FFS_SDO: R7019.2 R7020.2 U7002.3
FIVR_EN_R: R9608.2 R9906.2 XDP1.45
GPD2/LAN_WAKE#: CPU1.AM15 R1707.2 R1732.2
GPD11/LANPHYPC: CPU1.AW17 R1724.2
GPP_B2/VRALERT#: CPU1.AM11 TP1708.1
GPP_B4/CPU_GP3: CPU1.AY5 TP404.1
GPP_B18/GSPI0_MOSI: CPU1.AR7 R2007.2 R2019.1
GPP_B22: CPU1.AN5 TP2018.1
GPP_B23/SML1ALERT#: CPU1.AM7 R1837.2
GPP_C2/SMBALERT#: CPU1.R10 R1836.2
GPP_C5/SML0ALERT#: CPU1.W1 R1822.2 R1823.1
GPP_E0/SATAXPCIE0/SATAGP0: CPU1.H2 TP1602.1
GPP_E1/SATAXPCIE1/SATAGP1: CPU1.H3 TP1603.1
GPP_E2/SATAXPCIE2/SATAGP2: CPU1.G4 TP1604.1
GPP_E3/CPU_GP0: CPU1.A6 TP403.1
GSEN2_INT1: R7009.2 R7012.2 U7001.12
GSEN2_INT1_C: CPU1.BA7 R6925.2 R7009.1
GSEN2_INT1_C_HUB: R6925.1 U6901.17
GSEN2_INT2: R7010.2 R7013.2 U7001.11
GSEN2_INT2_C: CPU1.AY7 R6926.2 R7010.1
GSEN2_INT2_C_HUB: R6926.1 U6901.38
GSEN_INT1: CPU1.BA8 HOMBD1.9 R6921.2
GSEN_INT1_HUB: R6921.1 U6901.18
GSEN_INT2: CPU1.BB7 HOMBD1.10 R6922.2
GSEN_INT2_HUB: R6922.1 U6901.19
GSENSOR_CS: R7006.1 U7001.2
GSENSOR_SDO: R7005.2 R7007.2 U7001.3
GYRO_DRDY: CPU1.AP13 HOMBD1.12 R6924.2
GYRO_DRDY_HUB: R6924.1 U6901.39
GYRO_INT: HOMBD1.11 R7002.2 R7003.2
GYRO_INT_C: CPU1.AW7 R6923.2 R7003.1
GYRO_INT_C_HUB: R6923.1 U6901.20
GYRO_INT_P11: D7001.1 R7002.1
H_CATERR#: CPU1.D63 TP401.1
H_CPU_SVIDALRT#: CPU1.B63 R728.2
H_CPU_SVIDCLK: CPU1.A63 R732.1
H_CPU_SVIDDAT: CPU1.D64 R709.1 R726.2
H_CPUPWRGD: CPU1.A68 EC1701.1 R1714.1 TP1705.1
H_PECI: CPU1.A54 R2437.2
H_PROCHOT#: C2403.1 PR4469.1 PR4624.2 PR4668.2 R401.2 R403.1 R2416.2
H_PROCHOT#_EC: Q2408.D R2416.1 R2418.2
H_PROCHOT#_R: CPU1.C65 R403.2
H_VCCST_PWRGD: C1711.1 CPU1.B65 EC1708.1 R1716.2 R1719.1 R1722.2 U1701.4
HDA_BITCLK: CPU1.AY22 R1907.2
HDA_CODEC_BITCLK: EC1901.2 EC2709.1 R1907.1 R2720.1
HDA_CODEC_RST#: C2714.1 EC1902.1 HDA27.2 R1911.1 R2917.1
HDA_CODEC_SDIN0: HDA27.42 R2718.2
HDA_CODEC_SDOUT: EC2708.1 R1912.1 R2719.1
HDA_CODEC_SYNC: HDA27.41 R1908.1
HDA_RST#: CPU1.AW22 R1911.2
HDA_SDIN0: CPU1.BA21 R2718.1
HDA_SDOUT: CPU1.BB22 R1909.2 R1912.2
HDA_SPKR_R: D2701.2 RN2701.3(B)
HDA_SYNC: CPU1.BA22 R1908.2
HDD_DEVSLP: CPU1.J1 R6002.1
HDD_DEVSLP_R: HDD1.13 R6002.2
HDD_EN_PCH: CPU1.J4 TP1802.1
HDD_FALL_INT: CPU1.M3 R7012.1 R7015.2
HDMI_CLK: C5709.1 CPU1.G56
HDMI_CLK#: C5714.1 CPU1.F56
HDMI_CLK#_R: C5714.2 U5701.10
HDMI_CLK#_R_C: HDMI1.12 R5705.1 U5701.21
HDMI_CLK_R: C5709.2 U5701.9
HDMI_CLK_R_C: HDMI1.10 R5705.2 U5701.22
HDMI_DATA0: C5711.1 CPU1.G53
HDMI_DATA0#: C5708.1 CPU1.F53
HDMI_DATA0#_R: C5708.2 U5701.1
HDMI_DATA0#_R_C: HDMI1.9 R5703.2 U5701.30
HDMI_DATA0_R: C5711.2 U5701.2
HDMI_DATA0_R_C: HDMI1.7 R5703.1 U5701.29
HDMI_DATA1: C5712.1 CPU1.F58
HDMI_DATA1#: C5715.1 CPU1.E58
HDMI_DATA1#_R: C5715.2 U5701.4
HDMI_DATA1#_R_C: HDMI1.6 R5704.2 U5701.27
HDMI_DATA1_R: C5712.2 U5701.5
HDMI_DATA1_R_C: HDMI1.4 R5704.1 U5701.26
HDMI_DATA2: C5707.1 CPU1.F55
HDMI_DATA2#: C5710.1 CPU1.E55
HDMI_DATA2#_R: C5710.2 U5701.6
HDMI_DATA2#_R_C: HDMI1.3 R5702.2 U5701.25
HDMI_DATA2_R: C5707.2 U5701.7
HDMI_DATA2_R_C: HDMI1.1 R5702.1 U5701.24
HDMI_EC_DET#: KBC24.69 R5723.1
HDMI_EC_DET#_C: Q5704.D R5721.2 R5723.2
HGNDA: ED2903.2 HDA27.25 HPMIC1.3 R2906.2
HGNDB: ED2905.2 HDA27.26 HPMIC1.4 R2911.2
HOME_BTN#: KBC24.3 R2401.1 R2427.1
HOME_BTN#_C: HOMBD1.8 R2401.2
HOST_DEBUG_TX: KBC24.81 R2442.2 R2467.2 R2480.1 R2482.2
HPD_HDMI_CON: HDMI1.19 R5722.2 U5701.28
HPD_HDMI_CON_C: Q5704.G R5722.1
HSIO_OUT: R1734.1 U1702.6 U1702.7 U1702.8
HSIOPC_R: C1719.1 R1733.2 U1702.4
HSYNC_LCD: LCD1.36 Q5502.S R5517.1
HSYNC_R: Q5502.D R5516.1
HSYNC_TPNL: HOMBD1.4 R5516.2 R5517.2 R5518.2
HUB_PA1: R6918.2 R6919.1 U6901.11
HUB_PA2: R6916.2 R6917.1 U6901.12
HUB_PA3: R6914.2 R6915.1 U6901.13
HUB_PA4: R6912.2 R6913.1 U6901.14
HUB_PA5: R6910.2 R6911.1 U6901.15
HUB_PA6: R6908.2 R6909.1 U6901.16
I2C0_SCL: CPU1.N3 R2020.1 RN2007.1(A)
I2C0_SCL_R: AFTP6534.1 Q6504.6 R6505.2 RN6503.3(B) TP1.3
I2C0_SCL_TCH_PAD: CPU1.U6 EC6503.1 Q6504.1 R6505.1
I2C0_SDA: CPU1.M4 R2021.1 RN2007.2(A)
I2C0_SDA_R: AFTP6535.1 Q6504.3 R6506.2 RN6503.4(B) TP1.2
I2C0_SDA_TCH_PAD: CPU1.U7 EC6504.1 Q6504.4 R6506.1
I2C1_SCL: CPU1.N2 RN2008.2(A)
I2C1_SDA: CPU1.N1 RN2008.1(A)
I_ADP: C2435.1 KBC24.110 R2421.2 R2471.1
I_BATT: C2441.1 KBC24.114 R2423.2
I_SYS: C2427.1 KBC24.113 R2422.2 R2497.2
ICSP_CLK_R: DB3.2 R2466.2
ICSP_CLOCK: JTAG1.2 KBC24.101 R2420.2 R2466.1
ICSP_CLR: KBC24.87 R2414.1 R2465.1 R2477.1 R2483.2
ICSP_DATA: KBC24.102 R2464.2 R2474.1
ICSP_DATA_R: DB3.3 R2464.1
ICSP_MCLR_R: DB3.6 JTAG1.3 R2425.2 R2465.2 R2468.2 R2483.1
ILIM_HI: R3404.2 U3401.16
ILIM_LO: R3403.2 U3401.15
ILIM_SEL: R3405.2 U3401.4
INT2_SELECT: D7001.2 Q7001.5 R7008.1 R7013.1 R7017.2
INT_TP#: AFTP6536.1 D401.K R410.1 R2431.1 R6511.2 TP1.5
ISET: R5413.2 R5414.2 U5701.34
ITP_PMODE: CPU1.E8 R9932.2 R9933.1
JTAG_CLK: JTAG1.4 R2438.2 R2471.2
JTAG_PU: JTAG1.1 R2403.2
JTAG_RST#: C2419.1 R736.1 R2461.2 R2477.2
JTAG_TDO: JTAG1.5 R2439.2 R2474.2
KB_BL_CTRL#: AFTP6530.1 KBLIT1.3 Q6501.D
KB_CLOSE#_2: C7001.1 KBC24.23 LIDSW1.3 R7001.1
KB_DISABLE: CPU1.AY8 KBC24.109 R2022.1 R6920.1
KB_DISABLE_HUB: R6920.2 U6901.2
KBC_BEEP_R: D2701.1 RN2701.4(B)
KBC_PWRBTN#: EC6601.1 IOBD1.9 R2432.1
KSI0: AFTP6512.1 KB1.15 KBC24.98 RN2403.8(B)
KSI1: AFTP6501.1 KB1.26 KBC24.99 RN2403.7(B)
KSI2: AFTP6508.1 KB1.19 KBC24.6 RN2403.6(B)
KSI3: AFTP6509.1 KB1.18 KBC24.7 RN2403.5(B)
KSI4: AFTP6505.1 KB1.22 KBC24.104 RN2404.8(B)
KSI5: AFTP6506.1 KB1.21 KBC24.105 RN2404.7(B)
KSI6: AFTP6503.1 KB1.24 KBC24.107 RN2404.6(B)
KSI7: AFTP6502.1 KB1.25 KBC24.108 RN2404.5(B)
KSO0: AFTP6507.1 KB1.20 KBC24.2 RN2412.8(B)
KSO1: AFTP6511.1 KB1.16 KBC24.14 RN2412.7(B)
KSO2: AFTP6513.1 KB1.14 KBC24.15 RN2412.6(B)
KSO3: AFTP6518.1 KB1.9 KBC24.16 RN2412.5(B)
KSO4: AFTP6514.1 KB1.13 KBC24.37 RN2409.8(B)
KSO5: AFTP6510.1 KB1.17 KBC24.38 RN2409.7(B)
KSO6: AFTP6517.1 KB1.10 KBC24.39 RN2409.6(B)
KSO7: AFTP6515.1 KB1.12 KBC24.50 RN2409.5(B)
KSO8: AFTP6516.1 KB1.11 KBC24.46 RN2410.8(B)
KSO9: AFTP6504.1 KB1.23 KBC24.68 R2449.2 R2450.1
KSO10: AFTP6523.1 KB1.4 KBC24.72 RN2410.7(B)
KSO11: AFTP6522.1 KB1.5 KBC24.74 RN2410.6(B)
KSO12: AFTP6519.1 KB1.8 KBC24.75 RN2410.5(B)
KSO13: AFTP6520.1 KB1.7 KBC24.76 RN2411.8(B)
KSO14: AFTP6521.1 KB1.6 KBC24.77 RN2411.7(B)
KSO15: AFTP6524.1 KB1.3 KBC24.86 RN2411.6(B)
KSO16: AFTP6528.1 KBC24.92 KBLIT1.4 RN2411.5(B)
L_BKLT_CTRL: CPU1.R11 D5502.1 R5502.2
L_BKLT_EN: CPU1.R12 R2435.2
L_BKLT_EN_EC: KBC24.91 R2435.1 R2436.1
LCD_BRIGHTNESS: EC5501.1 LCD1.26 RN5501.4(A)
LCD_TST: D5502.2 R2419.2 RN5501.8(B)
LCD_TST_C: LCD1.23 RN5501.1(A)
LCD_TST_EN: D5501.2 KBC24.26 R2419.1
LCDVDD: C5505.1 C5507.1 C5508.2 LCD1.37 LCD1.38 U5501.3
LDO_AVDD: C2729.2 HDA27.37
LDO_VDD_CORE: C2701.2 HDA27.39
LID_CL_SIO#: D2402.K IOBD1.29 KBC24.41 R2433.1
LINE1-L_C: C2907.1 R2912.2
LINE1-L_R: C2908.1 R2913.2
LINE1_L: HDA27.33 R2912.1
LINE1_R: HDA27.34 R2913.1
LPC_FRAME#_DEBUG: DB1.6 R6801.2
LPC_LAD0: KBC24.59 RN1806.8(B) RN6801.1(A)
LPC_LAD0_C: DB1.2 RN6801.8(B)
LPC_LAD0_R: CPU1.AY13 RN1806.1(A)
LPC_LAD1: KBC24.60 RN1806.7(B) RN6801.2(A)
LPC_LAD1_C: DB1.3 RN6801.7(B)
LPC_LAD1_R: CPU1.BA13 RN1806.2(A)
LPC_LAD2: KBC24.61 RN1806.6(B) RN6801.3(A)
LPC_LAD2_C: DB1.4 RN6801.6(B)
LPC_LAD2_R: CPU1.BB13 RN1806.3(A)
LPC_LAD3: KBC24.62 RN1806.5(B) RN6801.4(A)
LPC_LAD3_C: DB1.5 RN6801.5(B)
LPC_LAD3_R: CPU1.AY12 RN1806.4(A)
LPC_LFRAME#: KBC24.58 R1801.1 R6801.1
LPC_LFRAME#_R: CPU1.BA12 R1801.2
LPSS_UART2_CTS#: CPU1.AD4 R2046.2
LPSS_UART2_RXD: CPU1.AD1 R2048.2
LPSS_UART2_TXD: CPU1.AD2 R2049.2
LVDS_VDD_EN_R: D5501.3 RN5502.8(B) U5501.1
M_A_A0: CPU1.AY50 DIMM1.98
M_A_A1: CPU1.BB50 DIMM1.97
M_A_A2: CPU1.AY51 DIMM1.96
M_A_A3: CPU1.BA50 DIMM1.95
M_A_A4: CPU1.BB52 DIMM1.92
M_A_A5: CPU1.BA51 DIMM1.91
M_A_A6: CPU1.BA52 DIMM1.90
M_A_A7: CPU1.AW52 DIMM1.86
M_A_A8: CPU1.AY52 DIMM1.89
M_A_A9: CPU1.BB54 DIMM1.85
M_A_A10: CPU1.AT50 DIMM1.107
M_A_A11: CPU1.BA54 DIMM1.84
M_A_A12: CPU1.AW54 DIMM1.83
M_A_A13: CPU1.AU46 DIMM1.119
M_A_A14: CPU1.AY54 DIMM1.80
M_A_A15: CPU1.BA55 DIMM1.78
M_A_BS0: CPU1.AU52 DIMM1.109
M_A_BS1: CPU1.AT48 DIMM1.108
M_A_BS2: CPU1.AY55 DIMM1.79
M_A_CAS#: CPU1.AU48 DIMM1.115
M_A_CKE0: CPU1.BA56 DIMM1.73
M_A_CKE1: CPU1.BB56 DIMM1.74
M_A_CLK0: CPU1.AT53 DIMM1.101
M_A_CLK1: CPU1.AT55 DIMM1.102
M_A_CLK#0: CPU1.AU53 DIMM1.103
M_A_CLK#1: CPU1.AU55 DIMM1.104
M_A_CS#0: CPU1.AU45 DIMM1.114
M_A_CS#1: CPU1.AU43 DIMM1.121
M_A_DIMA_ODT0: CPU1.AT45 DIMM1.116
M_A_DIMA_ODT1: CPU1.AT43 DIMM1.120
M_A_DQ0: CPU1.AL71 DIMM1.22
M_A_DQ1: CPU1.AL68 DIMM1.23
M_A_DQ2: CPU1.AN68 DIMM1.33
M_A_DQ3: CPU1.AN69 DIMM1.34
M_A_DQ4: CPU1.AL70 DIMM1.24
M_A_DQ5: CPU1.AL69 DIMM1.21
M_A_DQ6: CPU1.AN70 DIMM1.36
M_A_DQ7: CPU1.AN71 DIMM1.35
M_A_DQ8: CPU1.AR70 DIMM1.41
M_A_DQ9: CPU1.AR68 DIMM1.53
M_A_DQ10: CPU1.AU71 DIMM1.42
M_A_DQ11: CPU1.AU68 DIMM1.40
M_A_DQ12: CPU1.AR71 DIMM1.39
M_A_DQ13: CPU1.AR69 DIMM1.51
M_A_DQ14: CPU1.AU70 DIMM1.50
M_A_DQ15: CPU1.AU69 DIMM1.52
M_A_DQ16: CPU1.AF65 DIMM1.70
M_A_DQ17: CPU1.AF64 DIMM1.68
M_A_DQ18: CPU1.AK65 DIMM1.57
M_A_DQ19: CPU1.AK64 DIMM1.59
M_A_DQ20: CPU1.AF66 DIMM1.67
M_A_DQ21: CPU1.AF67 DIMM1.69
M_A_DQ22: CPU1.AK67 DIMM1.58
M_A_DQ23: CPU1.AK66 DIMM1.56
M_A_DQ24: CPU1.AF70 DIMM1.5
M_A_DQ25: CPU1.AF68 DIMM1.7
M_A_DQ26: CPU1.AH71 DIMM1.16
M_A_DQ27: CPU1.AH68 DIMM1.17
M_A_DQ28: CPU1.AF71 DIMM1.4
M_A_DQ29: CPU1.AF69 DIMM1.6
M_A_DQ30: CPU1.AH70 DIMM1.15
M_A_DQ31: CPU1.AH69 DIMM1.18
M_A_DQ32: CPU1.BB65 DIMM1.129
M_A_DQ33: CPU1.AW65 DIMM1.131
M_A_DQ34: CPU1.AW63 DIMM1.142
M_A_DQ35: CPU1.AY63 DIMM1.143
M_A_DQ36: CPU1.BA65 DIMM1.130
M_A_DQ37: CPU1.AY65 DIMM1.132
M_A_DQ38: CPU1.BA63 DIMM1.140
M_A_DQ39: CPU1.BB63 DIMM1.141
M_A_DQ40: CPU1.BA61 DIMM1.147
M_A_DQ41: CPU1.AW61 DIMM1.149
M_A_DQ42: CPU1.BB59 DIMM1.157
M_A_DQ43: CPU1.AW59 DIMM1.159
M_A_DQ44: CPU1.BB61 DIMM1.146
M_A_DQ45: CPU1.AY61 DIMM1.148
M_A_DQ46: CPU1.BA59 DIMM1.160
M_A_DQ47: CPU1.AY59 DIMM1.158
M_A_DQ48: CPU1.AT66 DIMM1.164
M_A_DQ49: CPU1.AU66 DIMM1.176
M_A_DQ50: CPU1.AP65 DIMM1.177
M_A_DQ51: CPU1.AN65 DIMM1.163
M_A_DQ52: CPU1.AN66 DIMM1.165
M_A_DQ53: CPU1.AP66 DIMM1.166
M_A_DQ54: CPU1.AT65 DIMM1.174
M_A_DQ55: CPU1.AU65 DIMM1.175
M_A_DQ56: CPU1.AT61 DIMM1.181
M_A_DQ57: CPU1.AU61 DIMM1.180
M_A_DQ58: CPU1.AP60 DIMM1.193
M_A_DQ59: CPU1.AN60 DIMM1.191
M_A_DQ60: CPU1.AN61 DIMM1.194
M_A_DQ61: CPU1.AP61 DIMM1.192
M_A_DQ62: CPU1.AT60 DIMM1.182
M_A_DQ63: CPU1.AU60 DIMM1.183
M_A_DQS_DN0: CPU1.AM70 DIMM1.27
M_A_DQS_DN1: CPU1.AT69 DIMM1.45
M_A_DQS_DN2: CPU1.AH66 DIMM1.62
M_A_DQS_DN3: CPU1.AG69 DIMM1.10
M_A_DQS_DN4: CPU1.BA64 DIMM1.135
M_A_DQS_DN5: CPU1.AY60 DIMM1.152
M_A_DQS_DN6: CPU1.AR66 DIMM1.169
M_A_DQS_DN7: CPU1.AR61 DIMM1.186
M_A_DQS_DP0: CPU1.AM69 DIMM1.29
M_A_DQS_DP1: CPU1.AT70 DIMM1.47
M_A_DQS_DP2: CPU1.AH65 DIMM1.64
M_A_DQS_DP3: CPU1.AG70 DIMM1.12
M_A_DQS_DP4: CPU1.AY64 DIMM1.137
M_A_DQS_DP5: CPU1.BA60 DIMM1.154
M_A_DQS_DP6: CPU1.AR65 DIMM1.171
M_A_DQS_DP7: CPU1.AR60 DIMM1.188
M_A_RAS#: CPU1.AU50 DIMM1.110
M_A_WE#: CPU1.AT46 DIMM1.113
M_VREF_CA_DIMMA: C1201.1 C1202.1 C1218.1 DIMM1.126 R4203.1 R4204.2 R4206.2 R4208.1
M_VREF_DQ_DIM0: C4202.1 CPU1.AY68 R4202.1
M_VREF_DQ_DIMMA: C1204.1 C1205.1 C1206.1 DIMM1.1 R4201.2 R4202.2 R4209.1 R4210.2
MCU_BOOT0: R6907.1 U6901.44
MCU_OSCI: C6909.1 U6901.5 X6901.1
MCU_OSCO: C6908.1 U6901.6 X6901.3
MCU_RST#: C6902.1 R6902.1 U6901.7
ME_FWP_EC: KBC24.80 R1909.1
ME_SUS_PWR_ACK: KBC24.42 RN1702.1(A)
ME_SUS_PWR_ACK_R: CPU1.AR13 R1708.1 R2039.2 RN1702.4(B)
MEM_SMBCLK: CPU1.R7 Q1801.3 RN1811.3(B)
MEM_SMBDATA: CPU1.R8 Q1801.6 RN1811.4(B)
MIC_GND: LCD1.20 R5501.1
MICBIASB: HDA27.32 R2921.1
MSCLK: JTAG1.6 R2441.2 R2475.2
MSDATA: JTAG1.7 R2476.2
MSM#: CPU1.AP56 TP617.1
MUTE_CTRL: C2901.1 R2917.2 R2918.2 U2901.2
NCT7718_DXN: C2606.2 C2607.2 Q2603.E THM261.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C THM261.2
P_SYS: PR4474.1 PR4632.1 R2422.1
PANEL_SIZE1: KBC24.24 LCD1.35 R2455.1
PBAT_PRES1#: AFTP4306.1 BATT1.5 RN4301.8(B)
PBAT_PRES#: D4301.3 EC4307.2 KBC24.97 PU4401.15 R2415.1 RN4301.1(A)
PBAT_SMBCLK1: AFTP4308.1 BATT1.3 RN4301.6(B)
PBAT_SMBDAT1: AFTP4307.1 BATT1.4 RN4301.7(B)
PCH_ALW_ON: KBC24.71 R2495.1 R4102.1
PCH_BATLOW#: CPU1.AU13 R1723.2
PCH_DPWROK: CPU1.BB20 EC1711.1 R1704.2 R1718.1 R2497.1
PCH_JTAG_TCK: CPU1.B56 R407.1 R9914.2
PCH_JTAG_TDI: CPU1.D59 R408.1 R9916.2
PCH_JTAG_TDO: CPU1.A56 R409.1 R9919.2 XDP1.52
PCH_JTAG_TMS: CPU1.C59 R416.1 R9917.2
PCH_PLTRST#: CPU1.AN10 R1713.2
PCH_PLTRST#_EC: C2402.1 KBC24.56 R2410.1
PCH_POPIRCOMP: CPU1.AU16 R413.1
PCH_RSMRST#: EC1712.1 KBC24.88 R1702.2
PCH_SMBCLK: DIMM1.202 Q1801.4 R7014.1 R9912.1 RN1810.3(B)
PCH_SMBDATA: DIMM1.200 Q1801.1 R7016.1 R9911.1 RN1810.4(B)
PCH_THERMTRIP#: CPU1.C63 EC401.1 R419.2
PCH_WAKE#: CPU1.BB15 R1703.2
PCI_CLK_LPC0: CPU1.AW9 R1804.1
PCI_CLK_LPC1: CPU1.AY9 R1805.1
PCIE_CLK_XDP_N: CPU1.F43 R9923.1
PCIE_CLK_XDP_P: CPU1.E43 R9913.1
PCIE_CLK_XDP_R_N: R9923.2 XDP1.42
PCIE_CLK_XDP_R_P: R9913.2 XDP1.40
PCIE_RCOMPN: CPU1.F5 R1604.1
PCIE_RCOMPP: CPU1.E5 R1604.2
PCIE_RX_CPU_N5: CPU1.F16 IOBD1.16
PCIE_RX_CPU_P5: CPU1.E16 IOBD1.17
PCIE_TX_CPU_N5: C1601.2 CPU1.C19
PCIE_TX_CPU_P5: C1602.2 CPU1.D19
PCIE_TX_WLAN_N5: C1601.1 IOBD1.19
PCIE_TX_WLAN_P5: C1602.1 IOBD1.20
PECI_EC: C2405.1 KBC24.94 R2437.1
PEG_CLK1_CPU: CPU1.A42 IOBD1.22
PEG_CLK1_CPU#: CPU1.B42 IOBD1.23
PIRQA#: CPU1.BB11 R1607.2
PLT_RST#: C1701.1 EC1703.1 EC6602.1 IOBD1.27 R1713.1 R1715.1 R2410.2 R6802.1
PLT_RST#_DEBUG: DB1.7 R6802.2
PM_PCH_PWROK: CPU1.BA20 R1706.2 RN1703.3(B)
PM_RSMRST#: CPU1.AY17 Q1701.3 R1702.1 R1704.1 R1720.2 R9904.1 RN1703.4(B)
PM_RSMRST#_M: Q1702.5 Q1702.6 R1737.2
PM_RSMRST#_R: Q1702.2 R1720.1
PM_RSMRST_PWRGD_XDP: R9904.2 XDP1.39
PME#: CPU1.AU11 TP1707.1
POWER_SW_IN#: C2426.1 KBC24.127 R2432.2 R2451.1
PQ3802_1: PQ4301.B PR4302.1 PR4304.2
PRE: R5415.2 R5416.2 U5701.16
PROC_SELECT#: CPU1.C64 R603.1
PS_ID: PQ4302.S PR4306.1
PS_ID_R: AFTP4305.1 DCIN1.4 PR4301.1
PS_ID_R2: PD4301.1 PD4301.2 PQ4302.D PR4301.2 PR4304.1
PSID: KBC24.36 PD4302.3 PR4305.2 PR4306.2
PSID_DISABLE#_R_C: PQ4301.C PQ4302.G PR4303.2
PSYS: PR4615.1 PR4632.2 PU4601.46
PTP_DIS#: AFTP6537.1 KBC24.90 TP1.6
PTP_INT#_EC: KBC24.33 R2431.2
PU4902_S5: PC5119.1 PR5114.2 PU5102.9
PU4902_VCNTL: PC5111.1 PR5117.1 PR5118.1 PU5102.10
PURE_HW_SHUTDOWN#: C2610.1 D4001.3 Q2602.D R2615.1
PWR_1D0V_BOOT: PR5210.1 PU5202.6
PWR_1D0V_BOOT_A: PC5217.1 PR5210.2
PWR_1D0V_BYP: PC5219.1 PR5214.1 PU5202.7
PWR_1D0V_EN: PC5220.1 PR5215.2 PR5217.2 PU5202.1
PWR_1D0V_FB: PC5218.2 PR5213.1 PR5216.2 PU5202.4
PWR_1D0V_FB_A: PC5218.1 PG5209.2 PR5216.1
PWR_1D0V_ILIMT: PR5209.2 PU5202.3
PWR_1D0V_LDO: PC5226.1 PU5202.5
PWR_1D0V_PG: PR5211.2 PR5212.2 PU5202.2
PWR_1D0V_PH: PC5217.2 PL5202.1 PU5202.10
PWR_1D5V_EN: PC5307.1 PR5305.2 PU5302.3
PWR_1D8V_EN: PC5306.1 PR5301.1 PR5306.2 PR5307.2 PU5301.8
PWR_1D8V_POK: PR5302.2 PR5308.2 PU5301.7
PWR_1D35V_BOOT: PR5101.1 PU5101.6
PWR_1D35V_BOOT_R: PC5117.1 PR5101.2
PWR_1D35V_BYP: PC5110.1 PR5102.1 PU5101.7
PWR_1D35V_C_R: PC5112.2 PR5108.1
PWR_1D35V_EN: PC5138.1 PR5105.2 PU5101.1
PWR_1D35V_IMAX: PR5106.2 PU5101.3
PWR_1D35V_LDO_P5: PC5113.1 PU5101.5
PWR_1D35V_PGOOD: PR5107.2 PR5110.2 PU5101.2
PWR_1D35V_PHASE: PC5117.2 PL5101.1 PU5101.10
PWR_1D35V_VFB: PR5103.2 PR5104.1 PR5108.2 PU5101.4
PWR_3D3V_CS2: PR4501.1 PU4503.5
PWR_3D3V_DRVH2: PU4502.1 PU4503.10
PWR_3D3V_DRVL2: PU4502.4 PU4503.11
PWR_3D3V_EN2: PR4527.1 PU4503.6
PWR_3D3V_FEEDBACK: PG4530.2 PR4512.1
PWR_3D3V_SW2: PC4517.2 PL4502.2 PU4502.5 PU4503.8
PWR_3D3V_VBST2: PR4508.2 PU4503.9
PWR_3D3V_VBST2_1: PC4517.1 PR4508.1
PWR_3D3V_VFB2: PR4512.2 PR4517.1 PU4503.4
PWR_5V3D3V_VREG3: PC4527.1 PG4533.2 PU4503.3
PWR_5V3D3V_VREG5: PC4524.1 PG4534.1 PU4503.13
PWR_5V_CS1: PR4502.1 PU4503.1
PWR_5V_DRVH1: PU4501.1 PU4503.16
PWR_5V_DRVL1: PU4501.4 PU4503.15
PWR_5V_EN1: PR4521.1 PU4503.20
PWR_5V_FEEDBACK: PG4531.2 PR4515.1
PWR_5V_SW1: PC4518.2 PL4501.1 PU4501.5 PU4503.18
PWR_5V_VBST1: PR4509.1 PU4503.17
PWR_5V_VBST1_1: PC4518.1 PR4509.2
PWR_5V_VCLK: AFTP4501.1 PR4503.1 PU4503.19
PWR_5V_VFB1: PR4515.2 PR4520.1 PU4503.2
PWR_5V_VO1: PG4532.2 PU4503.14
PWR_CHG_1: PD4405.K PD4406.K PR4403.1
PWR_CHG_ACDET: PC4402.1 PR4411.1 PR4444.2 PU4401.6
PWR_CHG_ACN: PC4416.2 PC4428.1 PG4402.2 PR4421.1 PU4401.1
PWR_CHG_ACOK: D2404.K PR4404.1 PR4410.2 PR4475.2 PU4401.5 R2469.1
PWR_CHG_ACP: PC4418.2 PC4428.2 PC4432.1 PG4406.2 PR4421.2 PU4401.2
PWR_CHG_BAT: PR4408.2 PU4401.17
PWR_CHG_BATDRV: PR4409.1 PU4401.18
PWR_CHG_BTST: PR4425.1 PU4401.25
PWR_CHG_BTST1: PC4421.1 PD4401.K PR4425.2
PWR_CHG_CELL: PR4424.2 PR4445.1 PR4449.2 PR4468.2 PU4401.16
PWR_CHG_CMPIN: PR4413.1 TP4401.1
PWR_CHG_CMPIN_1: PR4413.2 PU4401.13
PWR_CHG_CMPOUT: PR4415.1 TP4402.1
PWR_CHG_CMPOUT_1: PR4415.2 PU4401.14
PWR_CHG_CMSRC: PR4439.2 PU4401.3
PWR_CHG_HIDRV: PU4401.26 PU4406.1
PWR_CHG_IADP: PC4435.1 PR4472.2 PU4401.7
PWR_CHG_IBAT: PC4436.1 PR4473.2 PU4401.8
PWR_CHG_ILIM: PR4470.2 PR4471.1 PU4401.21
PWR_CHG_LODRV: PU4401.23 PU4406.8
PWR_CHG_PHASE: PC4414.1 PC4421.2 PL4401.1 PU4401.27 PU4406.9
PWR_CHG_PHASE_R: PC4414.2 PR4419.1
PWR_CHG_PMON: PC4437.1 PR4474.2 PU4401.9
PWR_CHG_PROCHOT#: PR4469.2 PU4401.10
PWR_CHG_REGN: PC4422.1 PD4401.A PR4410.1 PR4449.1 PR4470.1 PU4401.24
PWR_CHG_SCL: PG4401.1 PU4401.12
PWR_CHG_SDA: PG4408.1 PU4401.11
PWR_CHG_SRN: PR4417.1 PU4401.19
PWR_CHG_SRN_R: PC4412.1 PC4429.2 PG4403.1 PR4417.2
PWR_CHG_SRP: PR4438.1 PU4401.20
PWR_CHG_SRP_R: PC4401.1 PC4429.1 PG4407.1 PR4438.2
PWR_CHG_VCC: PC4410.1 PC4433.1 PR4403.2 PU4401.28
PWR_CPUCORE_SNUB: PC4709.1 PR4704.2
PWR_VCCGT_BOOTA: PR4802.1 PU4803.35
PWR_VCCGT_BOOTA_RC: PC4809.1 PR4802.2
PWR_VCCGT_COMP: PC4617.2 PC4618.2 PU4601.4
PWR_VCCGT_COMP_R: PC4618.1 PR4631.2
PWR_VCCGT_CSCOMP: PC4620.1 PC4621.1 PR4634.2 PR4639.2 PR4640.2 PU4601.6
PWR_VCCGT_CSNA: PG4809.1 PR4646.2
PWR_VCCGT_CSP1: PC4623.2 PR4651.1 PU4601.10
PWR_VCCGT_CSP2: PR4671.2 PU4601.9
PWR_VCCGT_CSPA: PG4808.1 PR4637.1 PR4651.2
PWR_VCCGT_CSREF: PC4623.1 PC4626.1 PR4646.1 PU4601.8
PWR_VCCGT_CSSUM: PC4620.2 PC4621.2 PR4637.2 PR4638.2 PU4601.7
PWR_VCCGT_DIFFOUT: PR4625.1 PR4626.1 PU4601.2
PWR_VCCGT_DISB#A: PR4807.1 PU4803.2
PWR_VCCGT_FB: PC4614.2 PC4617.1 PR4626.2 PR4631.1 PU4601.3
PWR_VCCGT_FB_R: PC4614.1 PR4625.2
PWR_VCCGT_GLA: PU4803.8 PU4803.9 PU4803.10 PU4803.11
PWR_VCCGT_ICCMAX: PR4662.1 PU4601.18
PWR_VCCGT_ILIM: PR4640.1 PU4601.5
PWR_VCCGT_ILIM_NTC: PR4634.1 PR4638.1 PR4639.1
PWR_VCCGT_IOUT: PC4615.1 PU4601.1 R9934.1
PWR_VCCGT_NTC: PR4655.1 PR4656.2 PR4661.1
PWR_VCCGT_PHASEDA: PC4809.2 PU4803.32 PU4803.34
PWR_VCCGT_PWMA: PU4601.16 PU4803.4
PWR_VCCGT_PWMB: PU4601.17 TP4601.1
PWR_VCCGT_SWA: PG4808.2 PL4801.1 PU4803.12 PU4803.13 PU4803.14 PU4803.15 PU4803.16 PU4803.17 PU4803.18
PWR_VCCGT_TSENSE: PC4630.1 PR4655.2 PU4601.11
PWR_VCCGT_VCCA: PC4808.1 PR4803.1 PU4803.6
PWR_VCCGT_VSN: PC4612.1 PR4619.1 PU4601.48
PWR_VCCGT_VSN_R: PC4611.2 PC4612.2 PR4618.2 PR4619.2
PWR_VCCGT_VSP: PC4611.1 PR4617.2 PU4601.47
PWR_VCCSA_BST: PR5001.2 PU5002.1
PWR_VCCSA_BST_RC: PC5005.1 PR5001.1
PWR_VCCSA_COMP: PC4602.1 PC4604.2 PU4601.43
PWR_VCCSA_COMP_L: PC4604.1 PR4672.2
PWR_VCCSA_COMP_R: PC4602.2 PR4602.1
PWR_VCCSA_CSN: PC4606.1 PC4607.1 PG5001.1 PR4606.2 PU4601.41
PWR_VCCSA_CSN_NTC: PR4606.1 PR4609.2
PWR_VCCSA_CSP: PG5011.1 PR4612.2
PWR_VCCSA_CSP1B: PC4606.2 PC4607.2 PR4609.1 PR4612.1 PU4601.40
PWR_VCCSA_DRVH: PU5001.4 PU5002.8
PWR_VCCSA_DRVL: PU5002.5 PU5003.4
PWR_VCCSA_ICCMAX: PR4660.1 PU4601.20
PWR_VCCSA_ILIM: PC4632.1 PR4611.1 PU4601.42
PWR_VCCSA_IOUT: PC4609.2 PR4613.1 PU4601.39
PWR_VCCSA_PWM: PU4601.36 PU5002.2
PWR_VCCSA_SW: PC5005.2 PG5011.2 PL5001.1 PU5001.1 PU5001.2 PU5001.3 PU5002.7 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCCSA_VSN: PC4603.1 PR4605.1 PU4601.44
PWR_VCCSA_VSN_R: PC4603.2 PC4605.2 PR4604.1 PR4605.2
PWR_VCCSA_VSP: PC4608.1 PR4608.1 PU4601.45
PWR_VCCSA_VSP_R: PC4605.1 PC4608.2 PR4607.2 PR4608.2
PWR_VCORE_ADDR_BOOT: PR4663.1 PU4601.21
PWR_VCORE_ALERT#: PR4666.2 PU4601.33
PWR_VCORE_BOOT: PR4701.2 PU4701.35
PWR_VCORE_BOOT_RC: PC4706.1 PR4701.1
PWR_VCORE_COMP: PC4601.2 PC4619.2 PU4601.26
PWR_VCORE_COMP_R: PC4601.1 PR4636.2
PWR_VCORE_CSN: PC4616.2 PC4634.2 PG4708.1 PR4633.2 PU4601.28
PWR_VCORE_CSNNTC: PR4629.1 PR4633.1
PWR_VCORE_CSP: PG4707.1 PR4627.2
PWR_VCORE_CSP_1A: PC4616.1 PC4634.1 PR4627.1 PR4629.2 PU4601.29
PWR_VCORE_DISB#: PR4703.1 PU4701.2
PWR_VCORE_DRVON: PR4703.2 PR4807.2 PU4601.35 PU5002.3
PWR_VCORE_EN: PR4630.1 PU4601.37
PWR_VCORE_GL: PU4701.8 PU4701.9 PU4701.10 PU4701.11
PWR_VCORE_ICCMAX: PR4658.1 PU4601.19
PWR_VCORE_ILIM: PC4633.2 PR4635.1 PU4601.27
PWR_VCORE_IOUT: PC4613.2 PR4628.1 PU4601.30
PWR_VCORE_NTC: PR4650.2 PR4652.1 PR4653.2
PWR_VCORE_PHASED: PC4706.2 PU4701.32 PU4701.34
PWR_VCORE_PWM: PU4601.22 PU4701.4
PWR_VCORE_ROSC_COREGT: PR4664.1 PU4601.14
PWR_VCORE_ROSC_SAUS: PR4659.1 PU4601.15
PWR_VCORE_SCLK: PR4665.2 PU4601.34
PWR_VCORE_SDIO: PR4667.2 PU4601.32
PWR_VCORE_SW: PG4707.2 PL4701.1 PR4704.1 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.16 PU4701.17 PU4701.18
PWR_VCORE_TSENSE: PC4628.1 PR4650.1 PU4601.23
PWR_VCORE_VCC: PC4631.1 PR4657.2 PU4601.13
PWR_VCORE_VCCA: PC4708.1 PR4702.1 PU4701.6
PWR_VCORE_VR_RDY: PR4670.1 PU4601.38
PWR_VCORE_VRHOT#: PR4668.1 PU4601.31
PWR_VCORE_VRMP: PC4629.1 PR4601.2 PU4601.12
PWR_VCORE_VSN: PC4622.2 PR4644.2 PU4601.25
PWR_VCORE_VSN_R: PC4622.1 PC4625.1 PR4644.1 PR4645.2
PWR_VCORE_VSP: PR4647.1 PR4669.2 PU4601.24
PWR_VCORE_VSP_L: PC4627.2 PR4669.1
PWR_VCORE_VSP_R: PC4625.2 PC4627.1 PR4647.2 PR4648.2
Q6204_G: Q6504.2 Q6504.5 R6510.2
Q6205_Q: Q6503.D R6503.2
Q6502_D: Q6502.D R6514.1
RESET_OUT#: EC1704.1 KBC24.73 Q2602.G R1706.1
REXT: R5710.1 U5701.18
RING2: HDA27.31 R2905.1
RING2_R: C2903.1 R2905.2
RING2_R_C: C2903.2 EC2905.1 R2906.1
RISING TIME2: C4016.1 U4002.1
RSMRST_PWRGD#: D4002.3 R4029.2 R4030.2 R4031.2 R4032.2 R4033.2
RSVD_F65: CPU1.F65 TP612.1
RSVD_G65: CPU1.G65 TP613.1
RSVD_TP_AK12: CPU1.AK12 TP606.1
RSVD_TP_AK13: CPU1.AK13 TP605.1
RSVD_TP_AW70: CPU1.AW70 TP615.1
RSVD_TP_AW71: CPU1.AW71 TP614.1
RSVD_TP_BA68: CPU1.BA68 TP602.1
RSVD_TP_BA70: CPU1.BA70 TP601.1
RSVD_TP_BB68: CPU1.BB68 TP603.1
RSVD_TP_BB69: CPU1.BB69 TP604.1
RTC_AUX_S5: C2503.1 D2501.3 R1730.1 R2106.1 R2472.2 RN1801.1(A) RN1801.2(A)
RTC_DET#: CPU1.P1 Q2505.D R2040.2
RTC_RST#: C1806.1 CPU1.AM16 EC1807.1 G1801.2 Q1802.D RN1801.3(B)
RTC_X1: C1804.2 CPU1.AM18 R1815.1 X1802.1
RTC_X2: C1803.2 CPU1.AM20 R1815.2 X1802.4
RTCRST_ON: EC1808.1 KBC24.31 Q1802.G R1816.1
RUNPWROK: KBC24.48 R2481.2
SA0_DIMA: DIMM1.197 R1201.1
SA1_DIMA: DIMM1.201 R1202.1
SATA_ACT#: CPU1.H1 R1606.2 TP1601.1
SATA_RX_CPU_N0: C6006.1 CPU1.F20
SATA_RX_CPU_P0: C6005.1 CPU1.E20
SATA_RXN0_R: C6006.2 HDD1.18 U6001.4 U6001.7
SATA_RXP0_R: C6005.2 HDD1.19 U6001.5 U6001.6
SATA_TX_CPU_N0: C6003.1 CPU1.B21
SATA_TX_CPU_P0: C6001.1 CPU1.A21
SATA_TXN0_R: C6003.2 HDD1.16 U6001.2 U6001.9
SATA_TXP0_R: C6001.2 HDD1.15 U6001.1 U6001.10
SD_RCOMP: CPU1.AB7 R1901.1
SENSE_PORTA: AFTP2910.1 ED2906.2 HPMIC1.5 R2924.1
SENSOR_I2C_SCL: HOMBD1.7 LCD1.31 R2020.2 R6928.2 RN6901.4(B) RN7001.2(A)
SENSOR_I2C_SCL_2G: RN7001.3(B) U7001.1
SENSOR_I2C_SCL_HUB: R6928.1 U6901.42
SENSOR_I2C_SDA: HOMBD1.6 LCD1.30 R2021.2 R6929.2 RN6901.3(B) RN7001.1(A)
SENSOR_I2C_SDA_2G: RN7001.4(B) U7001.4
SENSOR_I2C_SDA_HUB: R6929.1 U6901.43
SERIRQ: CPU1.AY11 KBC24.55 R1821.2
SIO_EXT_SCI#: KBC24.66 R2411.1
SIO_EXT_SCI#_R: CPU1.J2 R1608.2 R2411.2
SIO_EXT_SMI#: KBC24.10 R2412.1 R2457.1
SIO_EXT_SMI#_R: CPU1.L6 R802.1 R2412.2
SIO_EXT_WAKE#: CPU1.AD3 KBC24.116 R2041.2
SIO_PWRBTN#: CPU1.BA15 KBC24.52 R9926.1
SIO_RCIN#: CPU1.AW13 KBC24.53 R1820.2
SIO_SLP_A#: CPU1.AN16 TP1706.1
SIO_SLP_S3#: CPU1.AP15 KBC24.70 PR5125.1 PR5305.1 Q4007.G R4010.1 R4017.1 U4004.2
SIO_SLP_S4#: CPU1.BA16 KBC24.67 PR5105.1 PR5114.1 R4023.1 U4005.2
SIO_SLP_S5#: CPU1.AY16 TP1703.1
SIO_SLP_SUS#: CPU1.AN15 KBC24.96 PR5215.1 PR5306.1 R1729.2
SKTOCC#: CPU1.A65 TP402.1
SLEEVE: HDA27.30 R2922.1 U2901.3
SLEEVE_CTRL: R2915.2 U2901.5 U2901.6
SLEEVE_R: C2902.1 R2922.2
SLEEVE_R_C: C2902.2 EC2906.1 R2911.1
SLP_LAN#: CPU1.AW15 TP1704.1
SM_DRAMRST#: CPU1.AT13 ED501.1 R1203.2 R1204.1
SM_INTRUDER#: CPU1.AP16 R1730.2
SM_PGCNTL: CPU1.AW67 PR5111.1
SM_RCOMP_0: CPU1.AR18 R501.1
SM_RCOMP_1: CPU1.AT18 R502.1
SM_RCOMP_2: CPU1.AU18 R503.1
SMBCLK1: D4303.3 EC4305.1 KBC24.9 PG4401.2 PR4432.2 RN2402.3(B) RN4301.3(A)
SMBCLK2: KBC24.12 Q2604.3 R2459.1 RN2603.4(B)
SMBDA1: D4302.3 EC4306.1 KBC24.8 PG4408.2 PR4414.2 RN2402.4(B) RN4301.2(A)
SMBDA2: KBC24.11 Q2604.6 R2447.1 RN2603.3(B)
SML0_SMBCLK: CPU1.R9 RN1807.5(B)
SML0_SMBDATA: CPU1.W2 RN1807.6(B)
SML1_SMBCLK: CPU1.W3 Q2601.3 Q2604.4 R2459.2 RN1807.7(B)
SML1_SMBDATA: CPU1.V3 Q2601.6 Q2604.1 R2447.2 RN1807.8(B)
SPDIF_TP: HDA27.6 TP2702.1
SPI0_MOSI_XDP: C9903.1 R1826.1 R9909.2 XDP1.47
SPI1_CLK_ROM_R: EC2505.1 R2511.1 SKT252.6 SPI252.6
SPI1_HOLD_ROM_R: R2509.1 SKT252.7 SPI252.7
SPI1_SI_ROM_R: EC2506.1 R2512.1 SKT252.5 SPI252.5
SPI1_SO_ROM_R: EC2504.1 R2513.2 SKT252.2 SPI252.2
SPI1_WP_ROM_R: R2514.2 SKT252.3 SPI252.3
SPI_CLK_CPU: CPU1.AV2 R1806.2
SPI_CLK_ROM: R1806.1 R2404.1 R2505.2 R2511.2
SPI_CLK_ROM_EC: R2404.2 R2485.1
SPI_CLK_ROM_R: EC2503.1 R2505.1 SKT251.6 SPI251.6
SPI_CS_CPU_N0: CPU1.AU3 R1812.2
SPI_CS_CPU_N1: CPU1.AU2 R1828.2
SPI_CS_ROM_N0: R1812.1 R2490.1 R2501.1 SKT251.1 SPI251.1
SPI_CS_ROM_N1: R1828.1 R2491.1 R2502.1 SKT252.1 SPI252.1
SPI_HOLD_CPU: CPU1.AU4 R1811.2
SPI_HOLD_ROM: R1811.1 R1835.2 R2503.2 R2509.2
SPI_HOLD_ROM_R: R2503.1 SKT251.7 SPI251.7
SPI_SI_CPU: CPU1.AV3 R1808.2 R1824.2 R1825.1 R1826.2
SPI_SI_ROM: R1808.1 R2405.1 R2506.2 R2512.2
SPI_SI_ROM_EC: R2405.2 R2486.1
SPI_SI_ROM_R: EC2501.1 R2506.1 SKT251.5 SPI251.5
SPI_SO_CPU: CPU1.AW3 R1807.2
SPI_SO_ROM: R1807.1 R2406.1 R2507.1 R2513.1
SPI_SO_ROM_EC: R2406.2 R2487.1
SPI_SO_ROM_R: EC2502.1 R2507.2 SKT251.2 SPI251.2
SPI_WP_CPU: CPU1.AW2 R1809.2 R1827.2
SPI_WP_ROM: R1809.1 R1834.2 R2508.1 R2514.1
SPI_WP_ROM_R: R2508.2 SKT251.3 SPI251.3
SPKR: CPU1.AW5 R2006.2 RN2701.2(A)
SPKR_MUTE_TP: HDA27.7 TP2703.1
SRTC_RST#: C1805.1 CPU1.AN18 EC1806.1 RN1801.4(B)
SUS_STAT#/LPCPD#: CPU1.BA11 R1814.2
SUSACK#: KBC24.34 RN1702.2(A)
SUSACK#_R: CPU1.AP11 R1708.2 RN1702.3(B)
SUSCLK: R1813.2 R2493.1
SUSCLK_R: CPU1.BA17 EC1803.2 R1813.1
SWCLK: TP6904.1 U6901.37
SWDIO: TP6903.1 U6901.34
SYS_PRES1#: AFTP4309.1 BATT1.6 R4301.1
SYS_PWROK: CPU1.B6 EC1702.1 KBC24.89 R1717.1
T_CRIT#: R2601.1 R2604.2 THM261.4
THERM_SYS_SHDN#: Q2602.S R2601.2 R2602.1
THM_SML1_CLK: C2608.1 Q2601.4 RN2602.4(B) THM261.8
THM_SML1_DATA: C2609.1 Q2601.1 RN2602.3(B) THM261.7
TOUCH_PANEL_INTR#: CPU1.A7 D2402.A HOMBD1.5 R2429.1
TOUCHPAD_INTR#: CPU1.BA5 D401.A R404.2 R405.2 R410.2
TP1_AY4: CPU1.AY4 TP610.1
TP2_BB3: CPU1.BB3 TP611.1
TP4_BB5: CPU1.BB5 TP609.1
TP5_AU5: CPU1.AU5 TP607.1
TP6_AT5: CPU1.AT5 TP608.1
TP_EN#: KBC24.49 R2409.1 R6504.1
TP_ON#_GATE: C6502.2 Q6502.G Q6503.G R6504.2
TP_PMODE_XDP_RST_R_N: R9933.2 XDP1.46
TP_VDD: AFTP6531.1 C6503.1 R6502.2 R6503.1 R6511.1 R6514.2 RN6501.1(A) RN6501.2(A) RN6503.1(A) RN6503.2(A) TP1.1
TPAN_VDD: C5516.1 C5517.1 F5501.2 HOMBD1.3 R5507.2
TPCLK_C: AFTP6532.1 RN6502.3(B) TP1.8
TPDATA_C: AFTP6533.1 RN6502.4(B) TP1.7
U4006_CT: C4017.1 U4006.6
U4101_OUT: R4103.1 U4101.6 U4101.7 U4101.8
UART0_CTS#: CPU1.U4 TP2014.1
UART0_RTS#: CPU1.U3 TP2013.1
UART0_RXD: CPU1.U1 TP2011.1
UART0_TXD: CPU1.U2 TP2012.1
UART1_CTS#: CPU1.AB4 TP2017.1
UART1_RTS#: CPU1.AC3 TP2016.1
UART1_RXD: CPU1.AC1 TP2015.1
USB20_DN0_C: EU3602.1 TR3602.2 USB1.2
USB20_DN1_C: EU3604.1 TR3603.2 USB2.2
USB20_DP0_C: EU3602.6 TR3602.3 USB1.3
USB20_DP1_C: EU3604.6 TR3603.3 USB2.3
USB30_RX_CPU_N1: CPU1.H8 R3609.1
USB30_RX_CPU_N2: CPU1.J6 R3612.1
USB30_RX_CPU_N3: CPU1.J10 IOBD1.1
USB30_RX_CPU_P1: CPU1.G8 R3610.1
USB30_RX_CPU_P2: CPU1.H6 R3613.1
USB30_RX_CPU_P3: CPU1.H10 IOBD1.2
USB30_RXDN1_C: EU3601.1 EU3601.9 R3609.2 USB1.5
USB30_RXDN2_C: EU3603.1 EU3603.9 R3612.2 USB2.5
USB30_RXDP1_C: EU3601.2 EU3601.8 R3610.2 USB1.6
USB30_RXDP2_C: EU3603.2 EU3603.8 R3613.2 USB2.6
USB30_TX_CPU_N1: C3601.1 CPU1.C13
USB30_TX_CPU_N2: C3603.1 CPU1.B13
USB30_TX_CPU_N3: CPU1.B15 IOBD1.4
USB30_TX_CPU_P1: C3602.1 CPU1.D13
USB30_TX_CPU_P2: C3604.1 CPU1.A13
USB30_TX_CPU_P3: CPU1.A15 IOBD1.5
USB30_TXDN1_C: EU3601.4 EU3601.7 R3605.2 USB1.8
USB30_TXDN1_R: C3601.2 R3605.1
USB30_TXDN2_C: EU3603.4 EU3603.7 R3611.2 USB2.8
USB30_TXDN2_R: C3603.2 R3611.1
USB30_TXDP1_C: EU3601.5 EU3601.6 R3606.2 USB1.9
USB30_TXDP1_R: C3602.2 R3606.1
USB30_TXDP2_C: EU3603.5 EU3603.6 R3614.2 USB2.9
USB30_TXDP2_R: C3604.2 R3614.1
USB30_VCCA: C3401.1 C3403.1 C3404.1 EU3602.5 U3401.12 USB1.1
USB30_VCCB: C3507.1 C3508.1 C3512.1 C3513.1 EU3604.5 R3501.1 TC3501.1 U3501.1 USB2.1
USB_3+: R6904.1 R6906.2 U6901.33
USB_3-: R6905.2 U6901.32
USB_CAMERA_N: LCD1.16 TR5501.3
USB_CAMERA_P: LCD1.15 TR5501.2
USB_CHG_EN: KBC24.117 U3401.5
USB_CPU_PN0: CPU1.AB9 U3401.2
USB_CPU_PN1: CPU1.AD6 TR3603.1
USB_CPU_PN2: CPU1.AH3 TR6601.2
USB_CPU_PN2_C: IOBD1.8 TR6601.1
USB_CPU_PN3: CPU1.AD9 R6905.1
USB_CPU_PN4: CPU1.AJ1 TR5501.4
USB_CPU_PN5: CPU1.AF6 R6605.2
USB_CPU_PN5_C: IOBD1.13 R6605.1
USB_CPU_PN6: CPU1.AH1 R5510.2
USB_CPU_PN7: CPU1.AF8 TR6602.2
USB_CPU_PN7_C: IOBD1.11 TR6602.1
USB_CPU_PP0: CPU1.AB10 U3401.3
USB_CPU_PP1: CPU1.AD7 TR3603.4
USB_CPU_PP2: CPU1.AJ3 TR6601.3
USB_CPU_PP2_C: IOBD1.7 TR6601.4
USB_CPU_PP3: CPU1.AD10 R6906.1
USB_CPU_PP4: CPU1.AJ2 TR5501.1
USB_CPU_PP5: CPU1.AF7 R6606.2
USB_CPU_PP5_C: IOBD1.14 R6606.1
USB_CPU_PP6: CPU1.AH2 R5511.2
USB_CPU_PP7: CPU1.AF9 TR6602.3
USB_CPU_PP7_C: IOBD1.10 TR6602.4
USB_EN#: KBC24.13 R2479.1
USB_OC0#: CPU1.A9 RN1601.6(B) U3401.13 U3501.3
USB_OC1#: CPU1.C9 IOBD1.31 RN1601.5(B)
USB_OC2#: CPU1.D9 RN1601.8(B)
USB_OC3#: CPU1.B9 R2457.2 RN1601.7(B)
USB_PN0_R: TR3602.1 U3401.11
USB_PN6_TPNL: HOMBD1.15 R5510.1
USB_PP0_R: TR3602.4 U3401.10
USB_PP6_TPNL: HOMBD1.14 R5511.1
USB_PWR_EN#: IOBD1.30 R2434.2 R2479.2 U3501.4
USB_UART_SEL_D9: CPU1.P2 TP2006.1
USBCHARGER_CB0: KBC24.118 R2473.1 R3401.1
USBCOMP: CPU1.AB6 R1603.1
USBDET_CON#: Q2415.S R2452.1 USB1.D1
USBDET_CON#_R: KBC24.126 Q2415.D R2496.1
USBDISABLE: R6904.2 U6901.31
V_SM_VREF_CNT: C4201.1 CPU1.AY67 R4208.2
VCREF0: C2409.1 KBC24.25 R2424.1 R2448.1
VD_IN1_C: C2612.2 C2613.2 R2610.2 R2611.1
VOL_DOWN#: IOBD1.15 KBC24.21 R2460.1 R2499.1
VOL_UP#: IOBD1.12 KBC24.4 R2456.1 R2498.1
VR_CAP: C2418.1 KBC24.18
VR_EN: PR4630.2 R4002.2
VR_RDY: PR4614.2 PR4670.2 TP4603.1
VR_SVID_ALERT#: PR4622.2 PR4666.1 R727.2 R728.1
VR_SVID_CLK: PR4621.2 PR4665.1 R723.2 R732.2
VR_SVID_DATA: PR4623.1 PR4667.1 R709.2
VREFP: C2730.2 HDA27.28
VTT_EN: PC5120.1 PR5111.2 PR5125.2 PU5102.7
WIFI_RF_EN: CPU1.B7 EC6603.1 IOBD1.28 R1503.2
XCLK_BIASREF: CPU1.E42 R1803.1
XDP_BPM0: CPU1.C55 XDP1.21
XDP_BPM1: CPU1.D55 XDP1.23
XDP_BPM2: CPU1.B54 TP9901.1
XDP_BPM3: CPU1.C56 TP9902.1
XDP_DBRESET#: CPU1.B5 EC1706.1 R1701.2 R9925.2
XDP_DBRESET_XDP#: C9905.1 R9925.1 XDP1.48
XDP_PRDY#: CPU1.D56 XDP1.5
XDP_PREQ#: CPU1.D61 XDP1.3
XDP_PRSNT_PIN1: R9902.2 XDP1.1
XDP_SMBCLK: R9912.2 XDP1.53
XDP_SMBDAT: R9911.2 XDP1.51
XDP_SPI0_IO2: R1827.1 R9929.2 R9931.1 XDP1.60
XDP_TCK_JTAGX: CPU1.A59 R417.1 R9915.2
XDP_TCLK: CPU1.B61 R406.1 R9915.1 XDP1.57
XDP_TCLK1: R9914.1 XDP1.55
XDP_TDI: CPU1.D60 R422.1 R9916.1 XDP1.56
XDP_TDO_CPU: CPU1.A61 R423.1 R9919.1
XDP_TMS: CPU1.C60 R421.1 R9917.1 XDP1.58
XDP_TRST#: CPU1.B59 CPU1.C61 R402.1 XDP1.54
XTAL1: C2425.2 KBC24.123 X2401.1
XTAL2: KBC24.125 R2458.2 R2493.2
XTAL24_IN: C1801.2 CPU1.E37 R1802.1 X1801.1
XTAL24_OUT: CPU1.E35 R1802.2 R1810.1
XTAL24_OUT_R: C1802.2 R1810.2 X1801.3
XTAL_KBC_2: C2424.2 R2458.1 X2401.2
ZVM#: CPU1.AR56 TP616.1
N18046859: HDA27.4 HDA27.5 R2701.2
N78881610: PC4302.2 PR4308.2 PR4309.1 PU4301.4

Pads without a net: CPU1 A3 A4 A11 A17 A19 A23 A25 A26 A27 A29 A31 A33 A36 A38 A40 A45 A47 A50 A52 A69 AB1 AB3 AB11 AB12 AB13 AB62 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG1 AG2 AG3 AG4 AG62 AH7 AH8 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL43 AL46 AL50 AL53 AL56 AL60 AL61 AL63 AM1 AM2 AM3 AM4 AM22 AM23 AM48 AM50 AM52 AM53 AM56 AM58 AN1 AN2 AN3 AN7 AN8 AN21 AN22 AN25 AN27 AN45 AN46 AN48 AN50 AN52 AN53 AN55 AN56 AP1 AP2 AP3 AP4 AP5 AP7 AP8 AP21 AP22 AP25 AP27 AP30 AP33 AP37 AP40 AP45 AP46 AP48 AP50 AP52 AP53 AP55 AR21 AR22 AR25 AR27 AR30 AR32 AR33 AR37 AR38 AR40 AT11 AT15 AT21 AT22 AT25 AT27 AT30 AT32 AT33 AT37 AT38 AT40 AU1 AU21 AU22 AU25 AU27 AU30 AU33 AU37 AU40 AU56 AU58 AU63 AW1 AW20 AW25 AW27 AW29 AW31 AW33 AW35 AW37 AW39 AW42 AW44 AW46 AW48 AW56 AW68 AW69 AY1 AY2 AY3 AY20 AY21 AY25 AY26 AY27 AY29 AY30 AY31 AY33 AY34 AY35 AY37 AY38 AY39 AY42 AY43 AY44 AY46 AY47 AY48 AY56 B2 B3 B11 B17 B19 B23 B25 B26 B27 B29 B31 B33 B36 B38 B40 B45 B47 B50 B69 B70 BA3 BA4 BA25 BA26 BA27 BA29 BA30 BA31 BA33 BA34 BA35 BA37 BA38 BA39 BA42 BA43 BA44 BA46 BA47 BA48 BA67 BB2 BB4 BB25 BB27 BB29 BB31 BB33 BB35 BB37 BB39 BB42 BB44 BB46 BB48 BB57 BB66 C2 C4 C7 C8 C11 C12 C15 C16 C17 C20 C21 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C41 C42 C50 C51 C52 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D15 D16 D17 D20 D21 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D41 D42 D50 D51 D52 D54 D71 E1 E2 E3 E10 E22 E23 E25 E27 E28 E30 E38 E40 E48 E61 F6 F10 F11 F15 F18 F21 F25 F30 F46 F48 F50 F52 F60 F61 G1 G2 G3 G11 G13 G15 G16 G18 G21 G46 G50 G61 H5 H11 H13 H16 H63 J3 J5 J68 J71 K45 K46 L7 N9 N11 N12 P3 P4 P62 U8 U9 U11 U12 V62 W7 W8 W10 W11 W12; D4001 2; D4002 2; DCIN1 5; DIMM1 77 122 125 198; EU3602 3 4; EU3604 3 4; HDD1 2 7 12; HDMI1 13 14; HOMBD1 2; IOBD1 41 45; KBLIT1 2; LCD1 5 39; PU4401 4; PU4701 1 33; PU4803 1 33; PU5302 4; RN4301 4 5; RN5501 3 6; U1701 1; U3401 9; U4004 1; U4005 1; U4101 5; U5701 36; U6901 3 4 10 21 22 25 26 27 29 30 40 41 45 46; X1801 2 4; X1802 2 3; XDP1 61 62 63 64

## Via types
v1: diameter 0.356, hole 0.178, TOP to BOTTOM, 1011 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 2607 vias
v3: diameter 0.711, hole 0.406, TOP to BOTTOM, 588 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_RUN_FB: length 5.5
  BOTTOM w0.254: PU5301.2 30.77,11.45 30.36,11.86 v1(30.36,12.08) 30.36,12.12 PR5304.1 PC5305.2 PR5303.2
3V5V_CT1: length 3
  TOP w0.203: U4001.12 29.98,92.93
  TOP w0.254: C4001.1 v1(29.57,94.2) 29.88,93.9 29.88,93.23 29.98,93.12 29.98,92.93
3V5V_CT2: length 3.1
  TOP w0.203: U4001.10 30.79,92.93
  TOP w0.254: C4002.1 31.19,94.52 v1(30.87,94.2) 30.89,94.18 30.89,93.17 30.79,93.06 30.79,92.93
3V5V_S0_ON: length 13.4
  TOP w0.102: R4010.2 40.1,91.41 39.37,91.41 v1(39.32,91.36) 39.28,91.32 v2(39.28,90.62) ; U4001.5 v2(30.79,89.25) ; v2(29.88,89.25) 29.98,89.36 U4001.3
  L4 w0.102: v2(29.88,89.25) v2(30.79,89.25) 31.65,90.11 38.1,90.11 38.61,90.62 v2(39.28,90.62)
3V_5V_EN: length 165.1
  L3 w0.102: v2(133.18,32.23) 133.14,32.23 132.47,31.56 132.47,29.73 131.79,29.05 129.95,29.05 127.74,26.85 125.71,26.85 124.82,25.96 124.82,24.84 v2(124.96,24.71) ; v2(33.84,64.71) 33.43,65.12 29.67,65.12 28.52,63.98 v2(28.48,63.98)
  L4 w0.102: v2(124.96,24.71) 123.28,24.71 121.12,22.55 116.96,22.55 116.8,22.71 115.82,22.71 115.27,22.17 111.74,22.17 111.53,21.95 108.31,21.95 108.17,22.09 105.92,22.09 104.98,23.03 99.3,23.03 98.71,23.62 94.46,23.62 94.05,23.21 93.6,23.21 92.52,22.13 90.92,22.13 84.98,22.13 81.89,25.22 72.54,25.22 69.11,28.65 69.11,30.96 68.38,31.68 68.38,31.68 65.98,34.09 65.39,34.09 62.84,36.63 48.33,36.63 45.06,39.9 38.46,39.9 33.36,45 32.49,45 32.16,45.33 32.16,46.65 31.6,47.21 31.49,47.21 29.25,49.45 29.25,56.22 28.43,57.04 28.43,59.27 33.52,64.36 33.52,64.4 v2(33.84,64.71)
  BOTTOM w0.102: v2(33.84,64.71) 34.12,64.43 34.12,64.43 v1(34.37,64.17) 35.22,64.17 PR4527.2 ; PR4521.2 28.16,63.66 v2(28.48,63.98) ; R4009.1 136.66,35.55 D4001.1 137.35,34.42 137.57,34.2 137.57,31.74 137.15,31.32 137.15,30.21 136.88,29.94 C4009.1 136.52,30 R4006.1 135.72,31.83 133.57,31.83 v2(133.18,32.23)
3V_5V_POK: length 236.4
  TOP w0.102: R1728.2 112.18,91.6 v2(112.58,91.2) 112.58,90.33 C1710.1 ; PU4503.7 33.45,66.5 33.7,66.24 v2(33.7,65.75) ; R1718.2 102.75,71.58 103.12,71.21 103.73,71.21 EC1705.1 106.82,74.3 106.82,77.32 116.87,87.38 v1(116.87,93.39) v2(116.87,95.47)
  L3 w0.102: v2(112.58,91.2) 116.85,95.47 v2(116.87,95.47)
  L4 w0.102: v2(47.05,91.3) 45.52,91.3 44.1,89.88 41.82,89.88 39.15,87.22 38.39,87.22 37.19,86.02 37.19,81.71 36.53,81.05 36.53,75.97 35.85,75.28 35.85,67.4 34.2,65.75 v2(33.7,65.75) 33.05,65.1 33.05,64.18 28.23,59.35 28.23,56.96 29.04,56.14 29.04,49.38 31.41,47.01 31.52,47.01 31.96,46.57 31.96,45.25 32.41,44.8 33.27,44.8 37.24,40.83 v2(37.24,37.56)
  L6 w0.102: v2(47.05,91.3) 47.32,91.57 49.66,91.57 50.73,90.51 v2(51.24,90.51) 52.07,90.51 53.13,91.57 60.2,91.57 60.98,92.35 60.98,93.34 63.07,95.43 66.41,95.43 66.87,94.97 68.2,94.97 68.85,95.62 83.42,95.62 86.29,98.49 86.63,98.49 100.39,98.49 102.44,100.55 102.44,101.66 103.15,102.37 103.57,102.37 v2(104.05,102.84) ; v2(30.19,22.09) 30.63,21.65 30.63,16.17 34.05,12.75 34.05,9.6 31.4,6.95 v2(31.4,1.49)
  BOTTOM w0.102: PR5307.1 v2(31.4,1.49) ; v2(47.05,91.3) 47.04,91.3 46.96,91.22 R4033.1 ; v2(30.19,22.09) 30.66,22.56 30.66,27.23 33.13,29.7 33.13,35.2 35.41,37.48 37.17,37.48 v2(37.24,37.56) ; v2(112.58,91.2) 112.1,91.68 112.1,94.35 104.6,101.85 104.6,102.28 v2(104.05,102.84) ; PR4522.2 PR4519.2 33.05,65.1 v2(33.7,65.75) ; PR5217.1 51.37,90.37 v2(51.24,90.51)
3V_5V_POK#: length 4.5
  TOP w0.102: Q1701.6 110.76,95.91 110.53,96.15 110.53,97.11 v1(110.53,97.12) 110.58,97.17 110.93,97.17 111.41,96.69 R1726.1 Q1701.5
3V_5V_POK_C: length 11.2
  TOP w0.102: Q1701.2 111.41,92.13 R1728.1 111.29,91.82 110.69,91.22 R1729.1 110.4,91.97 v1(110.22,92.15) 109.69,92.68 109.69,94 110.14,94.46 110.14,95.12 110.24,95.22 110.24,96.21 110.14,96.31 110.14,97.85 109.86,98.13 109.81,98.13 R1727.2
5V_AUX_S5: length 43
  TOP w0.508: PG4534.2 27.62,70.45 26.7,69.54 v1(26.7,64.76) v2(26.7,60.29) ; R2726.1 26.37,35.78 v2(26.88,36.29)
  L6 w0.508: v2(30,46.47) 29.79,46.47 27.46,48.79 27.46,59.78 26.96,60.29 v2(26.7,60.29)
  BOTTOM w0.508: v2(30,46.47) 30,46.08 29.89,45.97 29.89,44.79 30.39,44.3 30.39,43.77 30.01,43.4 29.84,43.4 25.31,38.87 R2915.1 25.54,36.73 26.11,36.16 26.75,36.16 v2(26.88,36.29)
5V_HDMI_R_S5:
  vias: v1(19.53,92.07)
5V_HDMI_S5: length 1.8
  L6 w0.508: HDMI1.18 10.52,87.1 ; HDMI1.18 9.24,87.1 ; HDMI1.18 9.88,87.66
  vias: v1(15.93,90.42) v3(11.06,88.46) v3(11.54,89.17)
5V_S0: length 7.4
  TOP w0.203: 23.93,28.47 23.58,28.47 23.28,28.17 HDA27.13 ; HDA27.16 22.08,29.1 22.1,29.13 22.1,29.59
  TOP w0.508: v2(125.61,22.07) 125.32,22.36 R6510.1 ; v2(18.35,88.78) 17.82,88.25 D5701.3
  BOTTOM w0.508: R2612.1 137,68.48 137.29,68.19 v3(137.57,68.19)
  vias: v1(22.61,30.19) v1(24.82,92.32) v1(27.04,17.15) v1(76.44,28.85) v1(132.62,40.1) v1(133.38,31.3) v1(134.02,53.28) v1(134.45,33.75) v1(137.7,66.26) v2(25.89,94.46) v2(28.66,31.49) v2(132.16,39.29) v2(132.75,44.6) v2(133.13,34.38) v2(133.38,38.14) v3(25.69,93.31) v3(26.58,93.31) v3(27.46,93.31) v3(27.87,33.5) v3(28.35,18.03) v3(28.35,17.14) v3(29.37,36.42) v3(29.39,35.58) v3(76.49,30.45) v3(76.49,29.56) v3(77.25,30.07) v3(130.62,29.94) v3(131.48,29.95) v3(133.94,34.64)
5V_S5: length 208
  TOP w0.305: U1702.3 60.57,88.74 60.61,88.79 v2(60.61,88.84) ; PR4303.1 v2(33.31,95.47)
  TOP w0.508: v3(26.7,58.51) 26.83,58.51 28.23,59.91 31.25,59.91 v2(31.53,59.63) 31.53,59.61 31.25,59.33 31.25,58.28 31.8,57.74 31.8,56.27 31.27,55.75 PR4657.1 ; C4031.1 62.66,85.46 v2(62.58,85.54)
  L3 w0.254: v3(26.17,89.38) 27.85,89.38 32.54,94.07 32.54,94.71 v2(33.31,95.47)
  L3 w0.508: v2(55.15,92.45) 55.28,92.32 55.28,91.51 55.58,91.2 60.78,91.2 61.26,91.69 62.41,91.69 62.85,91.25 62.85,90.88 63.97,89.75 63.97,88.42 v2(63.66,88.11) 63.96,87.8 63.96,86.91 63.28,86.23 61.93,86.23 60.61,87.55 v2(60.61,88.84) ; v2(42,62.32) 41.69,62.01 41.69,56.23 43.85,54.07 43.85,50.39 44.74,49.5 46.6,49.5 v2(46.92,49.82)
  L4 w0.508: v2(55.15,92.45) 53.85,91.15 52.74,91.15 51.74,92.16 50.73,92.16 49.3,93.59 43.24,93.59 41.59,91.94 41.03,91.38 35.65,91.38 35.17,90.9 30.39,90.9 27.97,88.49 v3(26.19,88.49) ; v2(50.07,51.66) 49.31,51.66 v2(48.29,50.64) ; v2(31.53,59.63) 32.09,59.63 34.96,56.76 36.27,56.76 37.42,57.92 37.42,61.29 40.74,64.61 41.73,64.61 42.62,65.5 v2(43.31,65.5) 44.2,64.61 44.61,64.61 46.39,62.83 v2(46.39,62.71) 46.01,62.32 v2(42,62.32) ; 35.2,32.49 34.09,31.39 34.09,29.89 34.52,29.46 34.52,21.48 35.49,20.52 35.49,17.03 33.56,15.1 33.56,13.05 35.72,10.89 35.72,6.92 34.45,5.65 v2(34.45,3.9) ; v2(63.66,88.11) 63.74,88.03 63.74,86.63 62.64,85.54 v2(62.58,85.54)
  L6 w0.381: v2(22.13,56.1) 24.67,56.1
  L6 w0.508: v2(46.92,49.82) 47.47,49.82 v2(48.29,50.64)
  BOTTOM w0.203: PU4803.36 46.57,49.57 46.83,49.82 v2(46.92,49.82) ; PU4803.3 48.22,50.57 v2(48.29,50.64) ; PU4701.36 v2(42,62.32) ; PU4701.7 45.69,62.2 ; 50.27,49.88 PU4803.7
  BOTTOM w0.254: v2(22.13,56.1) 21.37,56.86 20.36,56.86 20.1,56.6 19.2,56.6 18.89,56.29 R3402.1 R3406.1 18.44,54.51 18.44,53.5 R3405.1
  BOTTOM w0.305: v2(62.58,85.54) 62.4,85.36 62.39,85.36 61.94,84.92 U4006.4
  BOTTOM w0.381: PR4671.1 26.89,52.16 26.19,52.16 v3(25.69,51.66) ; 142.53,69.18 142.95,69.6 142.95,70.41 142.46,70.89 142.46,72.42 142.92,72.88 142.92,75.52 140.68,77.76 140.68,79.96 137.68,82.96 EC8914.1 136.05,82.96 PR5117.2
  BOTTOM w0.508: PR4803.2 49.12,53.63 49.97,52.77 PC4807.1 ; 34.13,3.32 PC5301.1 ; 34.13,3.32 33.68,3.78 32.52,3.78 32.04,4.26 PU5301.6 ; 34.13,3.32 34.13,3.33 34.45,3.65 v2(34.45,3.9) ; PC4807.1 50.48,52.77 50.96,52.29 50.96,50.57 50.27,49.88 ; PC4807.1 49.94,52.27 49.94,51.78 v2(50.07,51.66) ; 45.69,62.2 45.63,62.27 45.63,63.2 PC4707.1 46.39,63.2 v2(46.39,62.71) ; C1718.1 60.73,88.73 v2(60.61,88.84) ; Q6505.E v2(144.71,29.37)
  vias: v1(24.31,87.6) v3(24.29,89.38) v3(24.29,88.49) v3(24.8,51.66) v3(25.18,89.38) v3(25.18,88.49) v3(25.31,87.22) v3(25.48,83.66) v3(25.51,82.77) v3(25.51,81.86) v3(25.51,81.02) v3(26.04,49.14) v3(26.07,50.01) v3(26.19,87.22) v3(26.37,80.31) v3(27.29,80.31) v3(62.9,31.08) v3(63.66,31.59) v3(63.66,30.7) v3(134.02,32.48) v3(135.34,32.48) v3(135.94,33.33) v3(141.26,67.53) v3(142.02,68.04) v3(142.02,67.15)
+1.8V: length 4.9
  TOP w0.254: R2725.1 24.82,34.54 v2(25.05,34.77)
  BOTTOM w0.254: Q4006.D 24.92,33.62 25.37,34.07 26.32,34.07 C4027.1 26.45,34.46 v1(25.91,35) 25.29,35 v2(25.05,34.77)
+3VLP: length 8.2
  TOP w0.102: R2463.2 157.07,33.11 v1(157.07,34.07) R2454.1 157.07,35.34 157.33,35.6 157.33,37.23 156.75,37.81 156.74,37.81 156.49,38.06 156.49,38.07 156.26,38.31 156.26,38.32 155.98,38.59 155.97,38.59 155.56,39 KBC24.120
+V1.00A_SIP: length 31.9
  TOP w0.508: v2(71.11,60.92) 71.11,59.81 R1803.2 ; v2(73.93,73.38) 74.64,73.38 C2104.1
  L6 w0.381: v2(77.68,71.06) 77.76,71.14 77.76,71.67 77.96,71.88 v2(77.96,72.74)
  L6 w0.508: v2(71.11,60.92) 68.69,63.35 68.69,67.71 67.98,68.42 67.98,70.45 67.22,71.21 67.22,72.79 67.67,73.25 67.8,73.25 68.56,74.01 v2(69.04,74.01)
  BOTTOM w0.102: v2(73.93,73.38) 74.41,73.38 74.62,73.59 74.62,73.99 CPU1.K17
  BOTTOM w0.127: CPU1.L1 75.09,83.62 75.06,83.65 75.06,84.12 74.95,84.23 74.94,84.24 74.94,84.82 v2(74.76,85.01)
  BOTTOM w0.203: CPU1.Y18 80.07,73.74 ; 80.07,73.74 80.16,73.74 v2(80.47,73.42) ; 80.07,73.74 80.21,73.87 80.22,73.87 80.74,74.39 CPU1.AB17 ; CPU1.A14 69.91,76.01 68.94,76.01 v2(68.92,75.99) ; v2(77.96,72.74) 77.96,73.32 CPU1.P18 ; CPU1.T1 77.85,83.61 77.85,84.9 v3(77.82,84.93) ; v2(69.05,78.42) 69.12,78.49 CPU1.A10
  BOTTOM w0.254: v2(84.66,72.14) 84.96,72.44 CPU1.AK20
  BOTTOM w0.305: CPU1.AB19 80.54,72.74 v2(80.47,72.74) ; CPU1.L21 76.59,71.06 v2(76.64,71.06) ; CPU1.AB20 80.56,72.1 v2(80.47,72.1)
  vias: v1(66.12,86.56) v2(67.79,86.24) v3(68.13,85.24) v3(76.99,88.99) v3(76.99,88.11)
+V1.00A_XDP: length 8.4
  TOP w0.254: R9927.2 105.26,41.28 C9904.1 105.03,41.28 104.61,40.87 C9902.1 103.21,42.1 103.21,43.33 104.07,44.19 v1(105.32,44.19) 106.27,44.19 R9932.1
+V1.00U_CPU: length 157.6
  TOP w0.152: R4038.1 74.13,72.92 72.37,72.92 72.28,73.01
  TOP w0.254: R2492.1 141.75,38.63 140.64,38.63 140.62,38.61 140.2,38.61 v1(140.19,38.6) 140.18,38.61 139.58,38.61 138.79,39.4 v2(138.79,40.33) ; v2(65.43,81.28) 65.43,81.04 66.61,79.87 66.61,79.26 66.31,78.96 65.91,78.96 65.49,78.54 65.49,78.12 65.7,77.9 65.7,75.83 66.94,74.6 66.94,72.96 67.31,72.59 68.1,72.59 68.47,72.96 R4036.1 68.78,73.5 71.79,73.5 72.28,73.01
  L4 w0.254: v2(99.04,83.55) 99.07,83.58 99.07,83.66 99.7,84.3 101.07,84.3 101.37,84 104.18,84 107.67,87.49 108.98,88.8 108.98,89.54 110.78,91.34 110.8,91.34 111.65,92.19 114.32,92.19 117.38,95.25 117.38,95.8 118.07,96.49 118.07,96.79 119.31,98.04 122.59,98.04 122.94,98.39 124.21,98.39 124.77,97.84 127.19,97.84 127.23,97.88 127.75,97.88 128.71,96.92 128.71,96.7 130.92,94.5 130.92,86.2 130.69,85.97 130.69,73.55 132.06,72.18 132.06,61.36 133.48,59.94 133.48,48.96 133.26,48.74 133.26,46.05 138.25,41.06 138.25,40.87 v2(138.79,40.33)
  L6 w0.254: v2(99.04,83.55) 98.45,83.55 98.24,83.34 92.25,83.34 91.98,83.61 87.97,83.61 87.97,83.6 84.49,83.6 84.25,83.36 81.99,83.36 81.77,83.58 74.02,83.58 74.02,83.59 72.93,83.59 72.29,82.94 69.91,82.94 69.21,82.94 68.69,83.46 67.42,83.46 65.43,81.47 v2(65.43,81.28)
+V1.8A: length 131.2
  L3 w1.016: v2(22,33.62) 22,35.92 22.51,36.43 22.51,37.42 20.21,39.72 18.21,39.72 17.05,40.87 17.05,43.74 16.34,44.45 16.34,53.52 14.51,55.34 14.51,56.98 15.03,57.5 15.13,57.5 15.78,58.15 15.78,63.6 15.27,64.11 15.27,67.03 14.31,68 14.31,73.19 13.49,74 13.49,74 12.78,74.72 12.78,76.87 13.49,77.59 13.49,79.42 12.73,80.18 12.73,86.97 22.73,96.97 25.56,96.97 28.38,99.79 32.98,99.79 34.64,101.45 41.04,101.45 41.79,100.7 45.02,100.7 45.63,101.31 49.42,101.31 51.85,98.89 65.38,98.89 65.96,99.47 69.82,99.47 72.94,102.58 v3(73.44,102.58)
  BOTTOM w0.508: PR5303.1 PC5305.1
  vias: v1(77.06,102.23) v3(32.04,12.54) v3(32.04,11.65) v3(32.93,11.65)
+V1.8A_SIP: length 7.1
  BOTTOM w0.127: CPU1.AA1 80.39,84.09 80.52,84.22 80.52,84.84 80.34,85.02 80.34,86.53 79.93,86.94 v2(79.72,87.14)
  BOTTOM w0.254: CPU1.AF16 82.57,74.98 82.15,74.56 82.15,72.12 v2(82.17,72.1)
  vias: v1(83.83,90.68) v3(85.53,91.56)
+V3.3A_SIP: length 36.9
  TOP w0.381: 87.54,87.34 87.54,88.23 86.84,88.93 86.84,91.02 86.81,91.04 86.81,91.24 85.01,93.04 85.01,94.07 84.04,95.04 84.04,95.65 84.17,95.77 R1701.1 84.16,96.09 R2101.1
  L3 w0.381: v2(83.52,70.71) 83.61,70.8 84.02,70.8 84.53,71.3 85.08,71.3 85.5,71.72 85.5,72.61 85.24,72.88 85.24,74.4 84.45,75.19 v2(84.45,76.21)
  L4 w0.508: v2(79.66,71.11) 80.63,70.15 83.07,70.15 83.5,70.57 83.5,70.68 v2(83.52,70.71)
  BOTTOM w0.178: CPU1.AK15 85.46,75.31 85.46,74.77 CPU1.AK17 ; CPU1.T16 77.96,75.46 v2(77.96,76.09)
  BOTTOM w0.203: v2(81.27,76.1) 80.34,76.1 v2(80.22,76.22)
  BOTTOM w0.254: v2(79.66,71.11) 79.62,71.15 79.62,72.68 CPU1.V19 ; v2(80.22,76.22) 80.05,76.05 CPU1.Y15 ; v2(82.38,76.31) 82.53,76.31 82.73,76.11 82.74,76.11 83.16,75.69 CPU1.AG15
  BOTTOM w0.305: CPU1.AD15 81.68,75.69 v2(81.27,76.1) ; v2(83.43,76.26) 83.41,76.23 CPU1.AG15 83.59,75.69 CPU1.AJ16 ; v2(83.52,70.71) 83.78,70.71 84.24,71.17 CPU1.AJ21 ; v2(84.45,76.21) 84.56,76.21 CPU1.AK15 85.48,76.09 v2(85.48,76.09) ; CPU1.Y16 CPU1.Y15
  vias: v1(87.8,86.16)
+VCCAMPHYPLL_1P0: length 2.4
  TOP w0.254: v1(76.54,77.18) 76.54,76.67 76.26,76.39
  BOTTOM w0.254: CPU1.K15 CPU1.L15 75.86,76.04 76.03,76.21 v2(76.03,76.23)
+VCCAPLL_1P0: length 1.8
  BOTTOM w0.127: v2(78.06,76.84) 78.06,76.6 78.98,75.69 CPU1.V15
  vias: v1(79.28,80.94)
+VCCCLK2: length 6.9
  TOP w0.254: v2(75.47,70.76) v1(75.47,69.94) 76.14,69.28 76.64,69.28 R2109.2 77.02,67.99 C2115.1
  BOTTOM w0.254: CPU1.K19 74.64,72.7 74.64,71.54 74.91,71.27 74.91,71.19 75.34,70.76 v2(75.47,70.76)
+VCCCLK4: length 10.9
  TOP w0.254: R2110.2 79.9,68.56 79.9,68.28 C2119.1 80.14,67.81 v2(79.36,67.02)
  L3 w0.127: 76.74,70.33 76.19,70.87 76.19,72.04 v2(76.28,72.13)
  L3 w0.254: v2(79.36,67.02) 79.92,67.58 79.92,68.29 79.66,68.55 78.52,68.55 76.74,70.33
  BOTTOM w0.254: CPU1.N20 76.59,72.44 v2(76.28,72.13)

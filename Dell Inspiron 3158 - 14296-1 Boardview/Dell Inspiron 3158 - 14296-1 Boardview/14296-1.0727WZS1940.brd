# Allegro board 14296-1.0727WZS1940.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCIO on L4: 74.58,75.41 76.36,73.63 76.36,69.69 75.47,68.8 74.96,68.8 74.71,68.55 74.71,66.9 74.96,66.64 76.11,66.64 76.36,66.9 79.66,66.9 80.68,67.91 84.49,67.91 84.87,67.53 84.87,65.75 83.22,64.1 76.36,64.1 75.85,64.61 73.69,64.61 72.8,65.5 72.3,65.5 71.53,66.26 71.53,70.07 72.17,70.71 72.17,71.47 72.93,72.23 72.93,72.61 72.8,72.74 71.66,72.74 71.03,73.37 71.03,75.28 68.23,78.07 68.23,80.87 68.74,81.37 68.74,83.91 70.39,85.57 70.39,86.71 69.73,87.37 69.73,88.13 68.76,89.1 68.76,89.91 69.63,90.77 70.31,90.77 73.31,87.78 73.31,81.63 72.55,80.87 72.55,80.36 72.68,80.23 72.68,78.71 74.58,76.8
+VCCMPHYGTAON_1P0_LS_SIP on TOP: 76.99,71.85 76.61,72.23 76.61,73.5 76.99,73.88 76.99,74.9 76.74,75.15 75.85,75.15 75.47,74.77 74.71,74.77 74.58,74.9 74.58,75.66 74.71,75.79 76.23,75.79 76.87,76.42 77.25,76.42 77.5,76.17 77.5,75.91 78.26,75.15 78.65,75.15 78.77,75.02 78.77,74.64 78.39,74.26 78.39,73.88 78.65,73.63 78.65,73.25 79.03,72.87 79.03,72.61 78.9,72.48 78.65,72.48 78.39,72.23 78.39,72.1 78.14,71.85 ; 3 cut-outs
+VCCMPHYGTAON_1P0_LS_SIP on TOP: 81.31,69.69 81.13,69.87 81.13,70.3 81.24,70.4 81.77,70.4 81.95,70.58 81.95,70.96 82.07,71.09 82.33,71.09 82.46,70.96 82.46,70.58 82.71,70.33 83.22,70.33 83.34,70.2 83.34,69.82 83.22,69.69
+VCCMPHYGTAON_1P0_LS_SIP on TOP: 60.74,78.96 60.36,79.34 60.36,80.87 61.91,82.42 65.44,82.42 65.64,82.21 65.64,82.04 65.51,81.91 65.23,81.91 64.62,81.3 64.62,80.92 64.52,80.82 63.86,80.82 63.74,80.69 63.74,79.77 63.23,79.27 62.54,79.27 62.24,78.96 ; 4 cut-outs
+VCCMPHYGTAON_1P0_LS_SIP on L3: 70.01,84.42 70.52,83.91 70.77,83.91 71.79,82.9 71.79,80.36 71.53,80.1 71.53,79.47 72.42,78.58 74.84,78.58 75.66,77.76 75.66,76.49 75.72,76.42 77.25,76.42 79.66,74.01 79.66,72.48 79.03,71.85 76.87,71.85 76.61,72.1 76.61,72.48 76.49,72.61 75.98,72.61 74.2,74.39 71.91,74.39 66.45,79.85 65.64,79.85 65.28,79.5 61.58,79.5 61.32,79.75 61.32,83.43 61.55,83.66 66.58,83.66 67.34,84.42
+VCCPDSW_3P3 on L4: 87.61,88.82 86.27,87.47 86.27,82.85 84.72,81.3 84.72,75.3 85.67,74.35 85.67,73.34 86.39,72.61 86.39,71.85 86.27,71.72 85.88,71.72 85.76,71.85 85.76,72.36 84.98,73.13 84.98,74.28 84.87,74.39 83.73,74.39 83.6,74.52 83.6,75.02 83.61,75.04 83.61,82.2 85.38,83.97 85.38,87.85 87.12,89.59 87.42,89.59 87.61,89.4
+VCCSA on TOP: 83.85,69.06 83.6,69.31 83.6,70.33 83.85,70.58 84.23,70.58 84.49,70.33 85.5,70.33 85.76,70.07 85.76,69.18 85.63,69.06
+VCCSA on TOP: 74.96,66.64 74.71,66.9 73.95,66.9 73.18,67.66 71.66,67.66 71.53,67.79 71.03,67.79 70.9,67.91 69.63,67.91 68.99,68.55 66.2,68.55 64.55,70.2 64.55,72.48 63.15,73.88 60.1,73.88 58.83,75.15 51.98,75.15 51.21,75.91 51.21,77.82 51.47,78.07 53.63,78.07 54.26,78.71 62.14,78.71 66.71,74.14 66.71,72.74 67.34,72.1 67.34,71.47 68.74,70.07 68.87,70.07 69.37,69.56 75.47,69.56 76.36,68.67 76.36,66.9 76.11,66.64 ; 10 cut-outs
+VCCSA on BOTTOM: 83.98,68.8 83.73,69.06 83.73,70.33 83.85,70.45 84.36,70.45 84.49,70.33 85,70.33 85.12,70.2 85.12,69.06 84.87,68.8
+VCCSA on BOTTOM: 51.98,74.64 51.72,74.9 51.72,76.68 50.58,77.82 50.58,78.96 50.58,79.15 50.65,79.22 54.01,79.22 54.77,78.45 60.48,78.45 60.61,78.33 60.61,74.9 60.36,74.64 ; 17 cut-outs
+VCCSA on BOTTOM: 74.62,66.26 74.61,66.26 74.48,66.26 74.31,66.43 74.31,67.08 74.16,67.22 73.52,67.22 73.26,67.48 73.26,67.58 73.03,67.81 73.03,68.07 73.61,68.65 73.61,68.99 73.42,69.18 73.42,69.36 73.62,69.57 73.62,69.89 73.43,70.07 73.43,70.3 73.7,70.57 73.7,70.71 73.82,70.82 73.82,70.83 74.84,70.83 75.22,70.45 75.72,70.45 75.98,70.2 75.98,66.51 75.72,66.26
+VCCSA on L3: 54.39,78.07 61.63,78.07 66.1,73.6 67.24,73.6 67.72,73.12 67.72,72.48 68.87,71.34 71.53,71.34 71.79,71.09 72.42,71.09 74.07,69.44 76.11,69.44 76.49,69.06 76.49,66.39 76.36,66.26 72.3,66.26 70.26,68.29 66.2,68.29 63.15,71.34 62.01,71.34 60.1,73.25 54.26,73.25 53.75,73.75 53.75,77.44
+VCCSA on L4: 77.88,67.02 79.15,68.29 84.23,68.29 84.74,68.8 84.74,70.07 84.36,70.45 83.98,70.45 83.22,69.69 76.61,69.69 75.6,68.67 75.09,68.67 74.84,68.42 74.84,66.9 74.99,66.74 75.95,66.74 76.23,67.02
+VCCSFR on TOP: 74.2,69.69 74.07,69.82 74.07,70.07 74.45,70.45 74.45,71.21 74.33,71.34 74.33,71.72 74.48,71.88 75.19,71.88 75.22,71.85 76.03,71.85 76.08,71.8 76.08,71.47 75.7,71.09 75.34,71.09 75.09,70.83 75.09,70.33 74.71,69.94 74.71,69.82 74.58,69.69 ; 1 cut-out
+VCCST_CPU on TOP: 67.34,72.92 67.22,73.04 67.22,74.77 67.34,74.9 67.72,74.9 67.85,74.77 67.85,73.53 67.88,73.5 67.88,72.99 67.8,72.92
+VDDQ_CPU_CLK on TOP: 83.6,59.15 83.47,59.28 83.47,60.42 83.73,60.67 83.98,60.67 84.23,60.93 84.23,61.18 84.74,61.69 86.27,61.69 86.39,61.56 86.39,61.18 86.14,60.93 86.01,60.93 85.76,60.67 85.76,60.29 84.61,59.15 ; 1 cut-out
GND on TOP: 79.28,72.36 79.15,72.48 79.15,72.99 78.9,73.25 78.9,73.63 78.52,74.01 78.52,74.14 79.03,74.64 79.03,75.02 79.15,75.15 79.66,75.15 79.79,75.02 79.79,74.64 79.92,74.52 81.57,74.52 81.69,74.64 82.58,74.64 82.71,74.52 82.71,73.88 82.58,73.75 81.82,73.75 81.69,73.88 80.04,73.88 79.79,73.63 79.79,72.48 79.66,72.36
GND on TOP: 90.33,55.34 90.2,55.47 90.2,56.36 90.33,56.48 94.01,56.48 94.14,56.36 94.14,55.47 94.01,55.34
GND on TOP: 90.46,58.26 90.33,58.39 90.33,60.04 90.58,60.29 93.76,60.29 94.01,60.04 94.01,58.77 93.89,58.64 91.09,58.64 90.71,58.26 ; 3 cut-outs
GND on TOP: 32.93,99.54 32.29,100.17 32.29,102.58 32.42,102.71 32.67,102.71 32.8,102.58 32.8,101.31 32.67,101.19 32.67,100.55 33.05,100.17 33.43,100.17 33.56,100.04 33.56,99.66 33.43,99.54
GND on TOP: 15.4,67.91 14.76,68.55 14.76,69.82 15.02,70.07 16.67,70.07 16.92,69.82 16.92,68.29 16.54,67.91
GND on TOP: 66.33,75.66 65.96,76.03 65.96,77.86 66.83,78.73 67.98,78.73 68.03,78.68 68.03,78.23 67.98,78.17 67.49,78.17 67.09,77.77 67.09,77.56 66.83,77.31 66.83,76.17 66.71,76.04 66.71,75.79 66.58,75.66
GND on TOP: 74.84,41.88 74.45,42.26 73.69,42.26 73.31,42.64 73.31,44.54 74.07,45.31 74.07,46.07 74.33,46.32 74.71,46.32 74.84,46.2 74.84,43.27 75.09,43.02 75.09,42.64 75.22,42.51 75.47,42.51 75.72,42.26 75.72,42.13 75.47,41.88 ; 4 cut-outs
GND on TOP: 2.45,36.16 2.32,36.29 2.32,37.31 2.45,37.43 11.84,37.43 12.48,38.07 12.48,39.46 13.49,40.48 13.49,41.75 13.75,42 14.38,42 14.64,41.75 14.64,39.97 16.29,38.32 16.67,38.32 17.69,39.34 17.69,40.48 18.07,40.86 18.83,40.86 20.35,39.34 20.35,37.56 20.23,37.43 15.65,37.43 14.38,36.16
GND on TOP: 59.98,92.15 59.8,92.33 59.8,92.99 61.42,94.61 62.37,94.61 62.44,94.54 62.44,93.33 61.85,92.74 61.05,92.74 60.46,92.15 ; 2 cut-outs
GND on TOP: 145.07,30.32 144.81,30.57 144.81,32.61 145.07,32.86 151.04,32.86 151.54,32.35 151.54,31.72 150.91,31.08 150.91,30.45 150.78,30.32
GND on TOP: 76.23,63.98 76.11,64.1 76.11,64.48 75.72,64.86 73.31,64.86 73.06,65.12 73.06,65.25 72.55,65.75 71.15,65.75 71.03,65.88 71.03,66.26 71.15,66.39 71.15,67.15 71.53,67.53 73.06,67.53 74.07,66.52 76.36,66.52 76.74,66.9 78.9,66.9 79.15,66.64 79.66,66.64 80.04,67.02 80.68,67.02 81.06,67.4 81.06,68.17 80.42,68.8 80.42,69.31 80.55,69.44 83.22,69.44 83.34,69.31 83.34,69.06 83.22,68.93 82.84,68.93 82.58,68.67 82.58,66.39 82.84,66.13 82.84,65.5 83.22,65.12 83.22,64.48 82.96,64.23 81.31,64.23 81.06,63.98 ; 22 cut-outs
GND on TOP: 84.47,70.38 84.4,70.44 84.4,70.74 84.98,71.32 84.98,73.34 84.95,73.38 84.43,73.89 84.43,74.82 84.6,75 85.14,75 85.84,74.29 85.84,72.05 85.98,71.92 87.19,71.92 87.4,71.71 90.62,71.71 90.71,71.8 90.71,72.15 90.09,72.76 90.09,73.47 90.15,73.53 90.61,73.53 90.68,73.46 90.68,73.2 91.08,72.81 92.33,72.81 92.4,72.74 92.4,71.39 92.38,71.36 91.07,71.36 90.85,71.15 90.85,70.92 90.74,70.81 90.44,70.81 90.11,71.13 87.42,71.13 87.32,71.24 85.81,71.24 84.95,70.38 ; 3 cut-outs
GND on TOP: 50.58,53.94 50.07,54.45 50.07,55.47 50.58,55.97 54.01,55.97 54.13,56.1 54.13,60.95 55.02,61.84 55.02,63.47 56.17,64.61 60.36,64.61 60.99,63.98 65.44,63.98 65.82,63.59 65.82,63.09 65.9,63.01 65.9,62.28 65.56,61.94 65.56,58.64 65.88,58.33 65.88,57.69 66.33,57.24 67.6,57.24 67.72,57.37 71.66,57.37 71.79,57.24 74.33,57.24 74.45,57.12 74.45,56.48 74.2,56.23 72.8,56.23 72.3,55.72 72.3,55.09 72.17,54.96 71.79,54.96 71.53,55.21 67.72,55.21 67.6,55.34 66.33,55.34 65.56,54.58 54.39,54.58 53.75,53.94 ; 32 cut-outs
GND on TOP: 53.12,94.33 52.99,94.46 52.99,95.6 53.12,95.73 53.63,95.73 53.75,95.6 53.75,94.58 53.5,94.33
GND on TOP: 70.39,40.48 70.26,40.61 70.26,42.13 69.88,42.51 69.5,42.51 69.37,42.64 69.37,42.89 69.88,43.4 69.88,43.66 70.16,43.94 70.92,43.94 71.66,44.67 72.04,44.67 72.42,44.29 72.42,42.39 72.8,42 72.8,41.62 72.68,41.5 71.91,41.5 70.9,40.48 ; 1 cut-out
GND on TOP: 76.23,56.1 76.11,56.23 76.11,56.74 76.23,56.86 76.87,56.86 76.99,56.99 76.99,57.75 77.12,57.88 82.96,57.88 83.09,57.75 83.09,56.48 82.71,56.1 ; 4 cut-outs
GND on TOP: 86.77,64.86 86.65,64.99 86.65,65.37 86.39,65.63 85.25,65.63 85.12,65.75 85.12,66.13 85.25,66.26 85.5,66.26 85.76,66.52 85.76,68.8 86.14,69.18 86.14,69.94 86.39,70.2 88.04,70.2 88.3,69.94 88.3,69.56 87.54,68.8 87.54,67.4 87.79,67.15 87.79,66.64 87.15,66.01 87.15,64.99 87.03,64.86 ; 8 cut-outs
GND on TOP: 80.4,82.14 80.27,82.26 80.27,84.25 80.55,84.52 80.55,86.2 80.8,86.45 82.84,86.45 82.96,86.33 84.23,86.33 84.61,85.95 84.61,84.93 84.87,84.68 85.25,84.68 85.63,85.06 86.01,85.06 86.14,84.93 86.14,84.42 86.01,84.3 85.63,84.3 84.74,83.41 83.73,83.41 82.46,82.14 ; 7 cut-outs
GND on TOP: 134.96,27.22 134.65,27.53 134.65,29.3 135.8,30.45 137.32,30.45 137.83,29.94 137.83,27.73 137.32,27.22
GND on TOP: 54.03,85.41 53.75,85.7 53.75,87.81 53.95,88.01 55.27,88.01 55.43,87.86 55.43,85.72 55.12,85.41 ; 2 cut-outs
GND on TOP: 15.65,79.22 15.27,79.6 15.27,80.99 15.53,81.25 16.59,81.25 16.95,80.89 16.95,79.42 16.75,79.22
GND on TOP: 42.26,88.74 41.76,89.24 41.76,91 41.94,91.17 44.83,91.17 46.13,92.47 46.13,92.81 46.63,93.32 48.32,93.32 48.93,92.71 48.93,89.12 48.55,88.74
GND on TOP: 34.7,75.15 34.45,75.41 34.45,76.42 34.58,76.55 35.08,76.55 35.21,76.68 35.21,78.2 35.47,78.45 36.51,78.45 36.76,78.2 36.76,75.46 36.46,75.15
GND on TOP: 67.39,92.8 66.88,93.31 66.88,94.3 66.58,94.61 66.58,95.88 66.71,96.01 68.92,96.01 69.09,95.83 69.09,92.8 ; 4 cut-outs
GND on TOP: 75.34,72.61 75.22,72.74 75.22,73.75 75.09,73.88 70.9,73.88 70.52,74.26 70.52,75.15 70.26,75.41 70.26,85.69 70.14,85.82 69.63,85.82 69.5,85.95 69.5,86.89 69.73,87.12 72.17,87.12 72.55,86.73 72.55,81.5 72.17,81.12 72.17,79.09 72.3,78.96 72.3,78.45 72.17,78.33 71.53,78.33 71.41,78.2 71.41,76.8 71.53,76.68 72.3,76.68 72.42,76.8 72.42,78.07 72.55,78.2 73.44,78.2 73.57,78.07 73.57,77.69 73.69,77.56 74.07,77.56 74.2,77.44 74.2,76.93 74.07,76.8 73.18,76.8 73.06,76.68 73.06,75.79 72.93,75.66 72.42,75.66 72.17,75.41 72.17,74.9 72.3,74.77 74.33,74.77 74.58,74.52 75.47,74.52 75.85,74.9 76.49,74.9 76.61,74.77 76.61,73.88 76.11,73.37 76.11,72.74 75.98,72.61 ; 4 cut-outs
GND on TOP: 15.63,76.55 15.58,76.6 15.58,78.76 15.78,78.96 17.91,78.96 18.04,78.83 18.04,78.15 17.94,78.05 16.62,78.05 16.36,77.79 16.36,76.98 16.31,76.93 16.31,76.63 16.24,76.55 ; 2 cut-outs
GND on TOP: 21.44,76.32 21.06,76.7 21.06,83.97 21.29,84.19 22.82,84.19 23.02,83.99 23.02,76.75 22.59,76.32
GND on TOP: 55.28,71.47 55.02,71.72 55.02,72.36 54.52,72.87 54.52,74.14 54.9,74.52 58.71,74.52 59.85,73.37 63.41,73.37 64.29,72.48 64.29,71.72 64.04,71.47 ; 6 cut-outs
GND on TOP: 82.33,48.61 82.2,48.74 82.2,51.02 81.95,51.28 80.55,51.28 80.3,51.02 79.66,51.02 79.53,51.15 79.53,54.45 79.28,54.7 76.23,54.7 76.11,54.83 76.11,55.21 76.23,55.34 83.09,55.34 84.23,56.48 84.23,56.99 84.36,57.12 85.63,57.12 85.88,57.37 85.88,58.77 86.14,59.02 87.66,59.02 87.79,58.9 87.79,58.64 87.54,58.39 87.15,58.39 86.9,58.13 86.9,57.37 86.14,56.61 85.88,56.61 85.63,56.36 85.63,49.5 84.74,48.61 ; 11 cut-outs
GND on TOP: 141.64,59.15 139.99,60.8 139.99,62.07 140.11,62.2 141.26,62.2 141.38,62.07 141.38,61.69 141.64,61.44 142.02,61.44 142.27,61.18 142.27,59.4 142.02,59.15 ; 1 cut-out
GND on TOP: 36.99,90.26 36.48,90.77 25.94,90.77 25.81,90.9 25.81,91.41 25.94,91.53 28.35,91.53 28.48,91.66 31.91,91.66 32.04,91.79 38.03,91.79 38.26,91.56 38.26,90.52 38.01,90.26 ; 3 cut-outs
GND on TOP: 46.18,25.57 44.09,27.65 41.31,27.65 40.8,28.16 40.8,31.46 41.18,31.84 44.99,31.84 45.37,31.46 46.26,31.46 48.67,29.05 53.12,29.05 53.25,28.92 53.25,28.29 51.8,26.84 51.8,25.75 51.62,25.57 ; 4 cut-outs
GND on TOP: 72.42,28.29 72.04,28.67 72.04,30.32 72.55,30.83 75.72,30.83 75.98,30.57 75.98,28.67 75.6,28.29 ; 2 cut-outs
GND on TOP: 75.09,46.7 75.09,48.35 74.96,48.48 73.82,48.48 73.69,48.61 73.69,48.86 73.82,48.99 75.47,48.99 75.72,48.74 75.72,46.83 75.6,46.7
GND on TOP: 12.99,50.01 12.61,50.39 12.61,51.66 11.72,52.55 2.45,52.55 2.19,52.8 2.19,54.96 2.45,55.21 8.92,55.21 9.43,54.7 10.45,54.7 11.21,55.47 11.21,70.45 10.45,71.21 9.43,71.21 8.92,70.71 1.43,70.71 0.79,71.34 0.79,74.26 1.05,74.52 7.65,74.52 8.41,75.28 8.41,77.44 8.92,77.95 8.92,79.85 8.67,80.1 8.29,80.1 7.91,80.49 7.91,80.87 8.16,81.12 8.8,81.12 8.92,81.25 8.92,82.14 9.3,82.52 10.32,82.52 10.5,82.7 11.06,82.14 11.06,79.44 10.57,78.96 10.57,77.44 10.83,77.18 11.34,77.18 11.72,76.8 11.72,74.26 11.34,73.88 11.34,73.63 11.97,73.63 12.35,73.25 13.75,73.25 15.4,71.6 15.4,71.21 15.27,71.09 13.88,71.09 13.37,71.6 11.97,71.6 11.84,71.47 11.84,71.09 12.1,70.83 12.99,70.83 13.75,70.07 13.75,68.42 15.53,66.64 15.53,50.26 15.27,50.01
GND on TOP: 29.75,75.02 29.62,75.15 29.62,77.18 30,77.56 31.15,77.56 31.4,77.31 31.4,76.8 31.66,76.55 31.66,75.28 31.4,75.02
GND on TOP: 134.14,73.5 134.02,73.63 134.02,74.01 134.14,74.14 134.14,78.71 134.27,78.83 134.91,78.83 135.16,78.58 135.16,73.75 134.91,73.5
GND on TOP: 65.46,36.42 65.21,36.67 65.21,37.28 65.03,37.46 64.01,37.46 63.84,37.64 63.84,38.39 64.08,38.63 65.74,38.63 65.89,38.47 65.89,37.89 66.02,37.76 66.02,36.47 65.97,36.42 ; 1 cut-out
GND on TOP: 51.21,37.94 50.71,38.45 50.71,40.1 51.59,40.99 51.59,42.64 52.1,43.15 58.33,43.15 58.48,42.99 58.48,38.73 57.69,37.94 ; 2 cut-outs
GND on TOP: 98.97,104.74 98.97,106.14 98.84,106.27 97.19,106.27 97.06,106.39 97.06,106.65 97.19,106.77 100.49,106.77 100.62,106.65 100.62,105 100.36,104.74
GND on TOP: 48.04,69.31 47.53,69.82 47.53,72.99 47.78,73.25 53.63,73.25 53.88,72.99 53.88,71.98 51.21,69.31 ; 3 cut-outs
GND on TOP: 99.09,79.98 98.46,80.61 98.46,81.76 98.58,81.88 98.84,81.88 99.09,81.63 99.09,80.74 99.6,80.23 99.6,80.1 99.47,79.98
GND on TOP: 39.28,35.91 38.89,36.29 38.89,37.94 39.28,38.32 40.29,38.32 40.67,37.94 40.67,36.29 40.29,35.91
GND on TOP: 69.63,93.57 69.37,93.82 69.37,95.34 69.76,95.73 72.93,95.73 73.44,95.22 73.44,94.07 73.18,93.82 70.64,93.82 70.39,93.57 ; 6 cut-outs
GND on TOP: 140.11,57.24 139.48,57.88 138.59,57.88 138.21,58.26 138.21,59.15 138.59,59.53 139.73,59.53 140.88,58.39 140.88,57.37 140.75,57.24 ; 2 cut-outs
GND on TOP: 69.37,66.9 69.12,67.15 69.12,67.53 68.87,67.79 67.47,67.79 67.34,67.91 67.34,68.29 67.47,68.42 68.99,68.42 69.63,67.79 70.77,67.79 70.9,67.66 70.9,67.15 70.64,66.9
GND on TOP: 150.4,63.98 150.18,64.2 149.74,64.2 149.47,64.46 149.47,65.02 149.57,65.12 151.16,65.12 151.42,64.86 153.32,64.86 153.58,64.61 153.58,64.1 153.45,63.98 ; 2 cut-outs
GND on TOP: 47.66,44.29 47.33,44.62 47.33,49.17 48.17,50.01 49.94,50.01 50.32,49.62 50.32,47.97 49.82,47.47 49.82,44.67 49.44,44.29 ; 2 cut-outs
GND on TOP: 144.64,62.32 144.56,62.4 144.56,63.11 144.42,63.25 144.42,64.29 144.47,64.34 145.52,64.34 145.71,64.15 145.71,63.73 145.98,63.46 145.98,62.92 145.38,62.32 ; 1 cut-out
GND on TOP: 123.73,35.65 123.35,36.04 120.94,36.04 120.68,36.29 120.68,42.13 114.46,48.35 114.46,50.13 114.21,50.39 112.94,50.39 112.68,50.13 112.68,49.88 112.55,49.75 112.3,49.75 112.17,49.88 112.17,50.39 111.92,50.64 110.65,50.64 110.27,50.26 94.77,50.26 93.89,49.37 91.85,49.37 90.33,50.89 90.33,51.4 90.58,51.66 95.66,51.66 95.79,51.78 120.81,51.78 121.7,52.67 121.7,53.56 121.95,53.82 123.1,53.82 123.73,54.45 127.16,54.45 127.54,54.83 127.54,55.21 127.67,55.34 128.05,55.34 128.18,55.21 128.18,48.35 127.67,47.85 126.78,47.85 126.02,47.08 126.02,45.31 125.89,45.18 125,45.18 124.49,44.67 124.49,44.04 124.37,43.91 124.37,43.66 125.76,42.26 126.14,42.26 126.4,42.51 126.78,42.51 126.91,42.39 126.91,41.75 126.78,41.62 126.78,40.61 126.91,40.48 127.92,40.48 128.18,40.23 128.18,38.19 127.92,37.94 127.54,37.94 127.41,37.81 127.41,37.56 126.91,37.05 126.14,37.05 126.02,37.18 125,37.18 124.75,36.92 124.75,36.54 125,36.29 125.13,36.29 125.25,36.16 125.25,35.78 125.13,35.65 ; 28 cut-outs
GND on TOP: 23.53,49.62 22.51,50.64 22.51,54.45 23.53,55.47 24.42,55.47 24.8,55.09 25.31,55.09 25.56,54.83 26.07,54.83 26.19,54.7 26.19,54.45 26.07,54.32 24.92,54.32 24.67,54.07 24.67,52.8 24.42,52.55 23.27,52.55 23.15,52.42 23.15,51.53 23.27,51.4 24.04,51.4 24.16,51.28 24.16,49.75 24.04,49.62 ; 3 cut-outs
GND on TOP: outline of 337 points within 0.79,0.73 166.59,115.28 ; 22 cut-outs
GND on TOP: 73.18,69.69 73.06,69.82 72.42,69.82 72.3,69.94 72.3,70.45 72.42,70.58 72.93,70.58 73.31,70.96 73.44,70.96 73.57,71.09 74.07,71.09 74.2,70.96 74.2,70.45 73.82,70.07 73.82,69.82 73.69,69.69 ; 2 cut-outs
GND on TOP: 55.15,78.96 54.52,79.6 54.52,82.01 55.89,83.38 59.01,83.38 59.72,84.09 59.72,85.31 59.8,85.39 59.95,85.39 60.15,85.18 60.15,81.1 59.8,80.74 59.8,79.17 59.6,78.96 ; 6 cut-outs
GND on TOP: 109.89,73.88 109.25,74.52 109.25,77.06 119.29,87.09 119.29,96.36 119.54,96.61 121.06,96.61 121.95,95.73 121.95,95.34 122.46,94.84 125.76,94.84 126.14,95.22 126.14,96.23 126.52,96.61 128.43,96.61 129.19,95.85 129.19,80.87 131.1,78.96 131.1,76.29 130.72,75.91 128.81,75.91 128.68,75.79 128.05,75.79 127.79,75.53 127.79,74.14 127.54,73.88 127.29,73.88 126.27,74.9 123.6,74.9 123.22,75.28 122.71,75.28 122.21,74.77 119.92,74.77 119.03,73.88 ; 16 cut-outs
GND on TOP: 122.97,25.75 122.84,25.88 122.84,26.38 122.59,26.64 122.54,26.64 121.88,27.3 120.64,27.3 120.56,27.39 120.56,29.05 121.06,29.56 122.59,29.56 123.35,30.32 124.62,30.32 124.75,30.19 124.75,26 124.49,25.75 ; 4 cut-outs
GND on TOP: 127.79,26.64 127.03,27.4 127.03,28.54 127.54,29.05 130.08,29.05 130.46,28.67 130.46,27.15 129.95,26.64
GND on TOP: 90.46,63.34 90.2,63.59 90.2,66.13 90.33,66.26 90.71,66.26 91.22,65.75 93.89,65.75 94.01,65.63 94.01,65.12 93.12,64.23 93.12,63.47 93,63.34 92.74,63.34 92.36,63.72 91.09,63.72 90.71,63.34 ; 2 cut-outs
GND on TOP: 43.09,56.86 42.7,57.24 42.7,61.48 43.3,62.07 45.5,62.07 46.01,61.56 46.01,60.55 45.19,59.73 45.19,57.37 44.69,56.86
GND on BOTTOM: 43.09,80.36 42.58,80.87 42.58,83.41 42.8,83.63 42.8,86.23 42.81,86.24 44.72,86.24 44.74,86.22 44.74,85.98 44.73,85.96 43.47,85.96 43.46,85.95 43.47,85.95 43.47,84.42 43.59,84.3 44.74,84.3 45.37,83.66 45.37,80.61 45.12,80.36 ; 2 cut-outs
GND on BOTTOM: 135.29,40.1 135.03,40.35 135.03,41.75 135.16,41.88 136.68,41.88 136.81,41.75 136.81,40.23 136.68,40.1
GND on BOTTOM: 33.69,25.49 33.43,25.75 33.43,28.03 33.69,28.29 35.21,28.29 35.34,28.16 35.34,25.62 35.21,25.49 ; 1 cut-out
GND on BOTTOM: 140.75,42.89 140.49,43.15 139.86,43.15 139.73,43.27 139.73,43.53 139.22,44.04 137.07,44.04 137.07,44.67 138.59,44.67 138.59,45.94 139.1,46.45 140.57,46.45 140.9,46.12 140.9,46.12 140.9,43.98 140.98,43.9 142.37,43.9 142.4,43.88 142.4,43.02 142.27,42.89 ; 1 cut-out
GND on BOTTOM: 113.82,30.45 113.7,30.57 113.7,31.21 113.44,31.46 111.67,31.46 111.54,31.59 111.54,34.77 111.79,35.02 115.86,35.02 116.11,34.77 116.11,30.83 115.73,30.45
GND on BOTTOM: 54.52,80.61 54.26,80.87 54.26,82.01 54.52,82.26 55.28,82.26 55.4,82.14 58.96,82.14 59.34,82.52 60.84,82.52 61.12,82.24 61.12,80.74 60.99,80.61
GND on BOTTOM: 132.49,64.36 132.37,64.48 132.37,71.6 132.49,71.72 135.16,71.72 135.29,71.6 135.29,70.45 135.41,70.33 136.05,70.33 136.18,70.2 136.18,68.93 135.29,68.04 135.29,64.48 135.16,64.36
GND on BOTTOM: 36.74,55.47 36.61,55.59 36.61,56.74 36.6,56.75 36.6,56.98 36.2,57.37 35.67,57.37 34.58,58.46 34.58,60.8 35.21,61.44 37.12,61.44 37.62,60.93 37.62,55.59 37.5,55.47
GND on BOTTOM: 48.42,68.8 48.04,69.18 48.04,71.6 47.66,71.98 47.66,72.99 47.91,73.25 53.5,73.25 54.01,72.74 54.01,69.06 53.75,68.8
GND on BOTTOM: 81.86,44.29 81.73,44.42 81.73,47.78 81.48,48.04 81.48,48.21 81.5,48.23 81.5,48.55 81.18,48.86 81.19,48.86 81.19,49.24 81.69,49.75 83.47,49.75 83.6,49.88 83.6,52.42 84.11,52.93 84.11,54.32 83.6,54.83 83.6,57.24 83.73,57.37 84.61,57.37 84.74,57.24 84.74,50.13 83.85,49.24 82.46,49.24 81.9,48.69 81.9,48.35 82.37,47.88 82.37,47.69 82.33,47.65 82.33,45.93 82.36,45.9 82.36,44.4 82.26,44.29
GND on BOTTOM: outline of 248 points within 0.91,0.51 166.59,109.99 ; 34 cut-outs
GND on BOTTOM: 131.73,49.62 131.35,50.01 131.35,58.13 131.6,58.39 132.87,58.39 133,58.26 133,51.28 133.38,50.89 133.38,50.01 133,49.62 ; 2 cut-outs
GND on BOTTOM: 26.02,72.69 25.94,72.76 25.94,73.22 25.99,73.27 26.37,73.27 26.47,73.37 26.47,73.83 26.58,73.93 28,73.93 28.43,74.36 28.43,74.82 28.56,74.95 29.6,74.95 29.7,75.05 29.7,76.4 29.98,76.68 31.91,76.68 32.04,76.55 32.04,76.04 32.29,75.79 32.8,75.79 32.93,75.91 33.81,75.91 33.81,76.42 33.94,76.55 35.08,76.55 35.21,76.68 35.21,78.2 35.47,78.45 37.5,78.45 37.75,78.2 37.75,76.93 37.37,76.55 37.37,75.91 37.12,75.66 35.72,75.66 35.21,75.15 33.05,75.15 32.93,75.02 32.93,73.75 32.67,73.5 30.33,73.5 29.52,72.69
GND on BOTTOM: 69.84,37.98 69.75,38.07 69.75,38.94 69.96,39.15 69.96,39.57 70.03,39.64 70.36,39.64 70.44,39.57 70.44,39.36 70.54,39.26 71.28,39.26 71.46,39.44 71.46,39.87 71.53,39.95 71.99,39.95 72.02,39.92 72.02,39.26 72.37,38.91 73.35,38.91 73.41,38.85 73.41,38.08 73.31,37.98 ; 2 cut-outs
GND on BOTTOM: 133.89,26.76 133.89,27.96 133.79,28.06 133.79,30.91 134.42,31.54 135.76,31.54 136.05,31.25 136.05,28.29 135.69,27.93 135.69,26.76 135.39,26.76 135.39,27.91 135.34,27.96 135.26,27.96 135.21,27.91 135.21,26.76 134.91,26.76 134.91,27.91 134.86,27.96 134.75,27.96 134.7,27.91 134.7,26.76 134.4,26.76 134.4,27.91 134.35,27.96 134.25,27.96 134.19,27.91 134.19,26.76 ; 4 cut-outs
GND on BOTTOM: 152.69,63.98 152.43,64.23 152.43,64.61 152.69,64.86 152.69,66.52 151.67,67.53 149.13,67.53 148.75,67.15 147.35,67.15 147.1,67.4 147.1,70.58 146.72,70.96 144.43,70.96 144.18,71.21 144.18,72.1 144.43,72.36 147.48,72.36 153.7,66.13 153.7,64.23 153.45,63.98
GND on BOTTOM: 62.9,48.61 62.77,48.74 62.77,52.55 62.26,53.05 62.26,55.21 61.75,55.72 55.15,55.72 54.13,54.7 54.13,53.18 53.75,52.8 51.59,52.8 50.71,53.69 50.07,53.69 49.94,53.82 49.94,55.09 50.71,55.85 53.63,55.85 54.26,56.48 54.26,60.67 54.9,61.31 54.9,63.47 55.91,64.48 60.61,64.48 61.37,63.72 65.31,63.72 66.83,62.2 66.83,61.18 66.33,60.67 63.91,60.67 63.66,60.42 63.66,59.02 63.53,58.9 62.9,58.9 62.39,58.39 62.39,57.88 62.52,57.75 63.66,57.75 63.79,57.88 63.79,58.26 63.91,58.39 64.93,58.39 65.69,57.63 65.69,55.72 64.8,54.83 64.8,52.67 64.55,52.42 64.55,51.53 64.42,51.4 63.91,51.4 63.79,51.28 63.79,48.86 63.53,48.61 ; 2 cut-outs
GND on BOTTOM: 49.69,95.22 49.56,95.34 49.56,96.36 49.31,96.61 46.64,96.61 46.01,97.25 43.47,97.25 42.58,98.14 42.58,99.66 43.59,100.68 43.59,101.69 43.85,101.95 47.78,101.95 51.21,98.52 54.9,98.52 55.02,98.39 55.02,97.5 54.77,97.25 51.59,97.25 50.45,96.11 50.45,95.34 50.32,95.22
GND on BOTTOM: 20.73,49.37 19.21,50.89 17.43,50.89 17.3,50.77 17.3,50.64 17.18,50.51 12.73,50.51 12.61,50.64 12.61,51.66 11.72,52.55 2.32,52.55 2.19,52.67 2.19,54.96 2.45,55.21 8.92,55.21 9.43,54.7 10.45,54.7 11.21,55.47 11.21,57.12 11.34,57.24 12.86,57.24 13.62,56.48 13.62,54.2 13.24,53.82 13.24,53.43 13.49,53.18 14,53.18 15.02,52.16 17.18,52.16 17.43,52.42 19.08,52.42 19.72,51.78 21.11,51.78 21.24,51.66 21.24,50.51 21.62,50.13 23.27,50.13 23.27,49.5 23.15,49.37 ; 2 cut-outs
GND on BOTTOM: 54.13,86.45 53.63,86.96 53.63,88.11 54.13,88.61 58.5,88.61 58.86,88.26 58.86,87.37 58.58,87.09 55.53,87.09 54.9,86.45 ; 2 cut-outs
GND on BOTTOM: 86.21,27.07 86.01,27.27 86.01,28.67 86.52,29.18 86.9,29.18 87.03,29.05 87.03,28.8 86.93,28.7 86.93,28.21 87.08,28.06 87.08,27.2 86.95,27.07
GND on BOTTOM: 117,20.03 116.87,20.16 116.87,22.32 117.51,22.95 117.51,25.37 117.76,25.62 118.52,25.62 119.16,24.99 119.16,24.61 118.4,23.84 118.4,20.16 118.27,20.03
GND on BOTTOM: 98.2,25.37 98.08,25.49 98.08,26.51 98.2,26.64 98.58,26.64 98.84,26.89 98.84,27.53 98.58,27.78 98.58,28.03 98.71,28.16 98.97,28.16 99.35,27.78 99.35,26.64 98.71,26 98.71,25.49 98.58,25.37
GND on BOTTOM: 68.49,21.18 68.23,21.43 68.23,22.32 68.36,22.45 70.77,22.45 70.9,22.32 70.9,21.94 70.14,21.18
GND on BOTTOM: 31.4,65.63 30.26,66.77 30.26,67.53 31.02,68.29 32.04,68.29 33.18,67.15 33.18,66.39 32.42,65.63
GND on BOTTOM: 91.6,108.17 89.06,110.71 87.79,110.71 87.66,110.58 87.66,109.19 87.28,108.81 84.61,108.81 84.49,108.93 84.49,110.46 85.5,111.47 88.81,111.47 89.19,111.85 95.16,111.85 95.66,111.35 95.66,109.31 94.52,108.17
GND on BOTTOM: 67.47,93.19 66.58,94.07 65.95,94.07 64.93,95.09 61.75,95.09 61.25,95.6 61.25,98.14 61.75,98.65 63.66,98.65 64.68,97.63 66.07,97.63 66.83,96.87 68.61,96.87 68.87,96.61 68.87,93.82 68.23,93.19
GND on BOTTOM: 101.11,71.23 98.84,73.5 98.84,75.28 97.82,76.29 97.82,77.82 98.46,78.45 99.35,78.45 99.6,78.71 99.6,79.47 99.09,79.98 99.09,80.49 99.22,80.61 99.93,80.61 101.07,79.47 101.07,78.2 103.69,75.58 103.69,71.72 103.19,71.23
GND on BOTTOM: 87.41,90.77 86.01,92.17 85.38,92.17 84.87,91.66 82.96,91.66 81.69,92.93 73.06,92.93 71.79,94.2 71.79,95.6 72.55,96.36 76.94,96.36 77.63,95.68 82.48,95.68 84.72,97.91 91.83,97.91 93.12,96.61 93.12,95.98 92.87,95.73 92.87,95.47 93.76,94.58 93.76,92.68 91.85,90.77
GND on BOTTOM: 78.2,73.46 77.99,73.66 77.99,73.96 77.85,74.1 77.45,74.1 77.39,74.16 77.37,74.16 77.33,74.21 77.33,74.61 77.41,74.69 78.6,74.69 78.73,74.82 78.73,75.21 78.47,75.47 78.25,75.47 78.16,75.55 78.16,75.79 78.27,75.91 78.52,75.91 79.05,75.38 79.6,75.38 79.71,75.27 79.71,74.87 79.84,74.74 80.28,74.74 80.58,75.04 80.58,75.88 80.65,75.95 80.94,75.95 81.22,75.67 81.22,75.52 81.41,75.32 81.92,75.32 82.01,75.23 82.01,74.86 81.92,74.77 80.79,74.77 80.13,74.1 79.86,74.1 79.59,73.84 79.59,73.55 79.5,73.46
GND on BOTTOM: 140.24,53.43 139.99,53.69 139.99,57.37 138.97,58.39 138.97,59.02 138.84,59.15 138.84,61.44 139.22,61.82 141.76,61.82 142.15,61.44 142.15,56.48 141.76,56.1 141.76,53.69 141.51,53.43
GND on BOTTOM: 10.95,72.87 9.3,74.52 8.16,74.52 7.69,74.98 8.11,75.85 7.61,76.67 7.61,77.52 8.29,78.2 9.3,78.2 9.56,77.95 10.45,77.95 10.7,77.69 10.7,77.31 10.83,77.18 11.34,77.18 11.72,76.8 11.72,75.53 12.35,74.9 14.51,74.9 14.64,74.77 14.64,74.39 14.38,74.14 12.35,74.14 12.22,74.01 12.22,73.12 11.97,72.87 ; 1 cut-out
GND on BOTTOM: 48.8,25.62 48.17,26.26 47.18,26.26 46.91,25.99 45.35,25.99 45.1,26.23 45.1,26.23 43.9,27.44 42.4,27.44 42.27,27.57 42.27,28.45 42.37,28.55 42.91,28.55 42.92,28.56 43.01,28.56 43.2,28.74 43.2,30.94 43.05,31.08 41.07,31.08 40.89,31.26 40.89,31.87 39.79,32.98 39.79,34.63 38.73,35.69 38.73,37.68 38.86,37.81 39.83,37.81 40.25,38.23 40.25,41.22 40.32,41.29 41.49,41.29 41.49,36.14 46.39,31.24 49.57,31.24 52.1,28.7 52.1,25.75 51.98,25.62 ; 2 cut-outs
GND on BOTTOM: 58.53,34.1 55.06,37.57 52.13,37.57 51.48,38.23 51.01,38.23 51,38.22 48.52,38.22 47.91,38.83 47.91,42.26 47.53,42.64 47.53,43.4 47.15,43.78 47.15,49.24 47.4,49.5 49.44,49.5 49.69,49.24 49.69,48.61 49.44,48.35 49.05,48.35 48.93,48.23 48.93,47.59 49.05,47.47 49.69,47.47 49.82,47.34 49.82,43.66 49.05,42.89 49.05,41.37 49.31,41.12 50.2,41.12 50.45,41.37 50.45,41.75 50.96,42.26 50.96,42.64 51.47,43.15 56.67,43.15 56.93,42.89 57.31,42.89 57.56,42.64 57.56,41.75 58.07,41.24 58.07,38.48 58.67,37.88 59.14,37.88 59.43,37.59 59.43,34.19 59.35,34.1 ; 5 cut-outs
GND on BOTTOM: 55.4,70.96 55.02,71.34 55.02,72.36 54.01,73.37 54.01,74.18 54.09,74.26 60.62,74.26 60.74,74.15 60.74,71.17 60.53,70.96 ; 4 cut-outs
GND on BOTTOM: 102.27,105.38 102.14,105.5 102.14,108.43 102.39,108.68 104.93,108.68 105.57,109.31 105.95,109.31 106.59,108.68 106.97,108.68 107.09,108.81 107.09,109.19 107.22,109.31 107.6,109.31 107.73,109.19 107.73,108.81 107.86,108.68 108.36,108.68 108.49,108.81 108.49,109.19 108.62,109.31 109.63,109.31 109.76,109.44 109.76,111.47 109.89,111.6 110.52,111.6 110.65,111.47 110.65,105.76 110.27,105.38
GND on BOTTOM: 87.79,103.73 86.14,105.38 86.14,107.54 86.65,108.04 89.44,108.04 91.22,106.27 91.22,105.38 89.57,103.73
GND on BOTTOM: 70.24,28.29 70.11,28.42 70.11,31.79 69.73,32.18 69.73,33.9 69.83,34 81.57,34 85.12,37.56 90.96,37.56 91.6,36.92 95.54,36.92 95.66,37.05 98.33,37.05 98.84,36.54 98.84,32.61 97.44,31.21 95.79,31.21 94.01,29.43 88.17,29.43 87.41,30.19 81.57,30.19 80.42,29.05 80.42,28.42 80.3,28.29 ; 3 cut-outs
GND on BOTTOM: 54.77,78.71 53.75,79.72 50.58,79.72 50.45,79.85 50.45,80.61 50.58,80.74 54.01,80.74 54.26,80.49 59.85,80.49 60.61,79.72 60.61,78.83 60.48,78.71 ; 5 cut-outs
GND on BOTTOM: outline of 140 points within 0.79,81.5 122.29,115.16 ; 6 cut-outs
GND on BOTTOM: 95.28,101.69 94.65,102.33 94.65,102.81 95.17,103.33 95.17,104.5 96.04,105.38 96.15,105.38 96.22,105.45 97.16,105.45 97.52,105.1 97.52,101.87 97.34,101.69
GND on BOTTOM: 80.07,78.52 79.85,78.75 79.66,78.75 79.48,78.92 79.48,79.32 79.64,79.48 79.88,79.48 79.93,79.53 79.93,80.55 79.5,80.98 79.5,81.29 80.2,81.99 80.2,82.06 80.61,82.06 80.61,82.05 80.61,81.31 80.57,81.27 80.57,80.26 80.81,80.02 80.98,80.02 80.98,79.61 80.54,79.17 80.54,78.85 80.57,78.82 80.57,78.74 80.35,78.52
GND on BOTTOM: 89.19,77.95 88.93,78.2 88.93,78.71 89.82,79.6 90.08,79.6 90.2,79.47 90.2,79.22 89.95,78.96 89.95,78.71 90.2,78.45 91.09,78.45 91.22,78.33 91.22,78.2 90.96,77.95
GND on BOTTOM: 118.9,30.19 117.76,31.34 117.76,35.65 116.87,36.54 113.44,36.54 113.19,36.8 113.19,40.86 115.09,42.77 115.09,52.04 114.18,52.95 114.18,80.23 115.22,81.27 115.22,94 112.2,97.02 111.51,97.02 110.9,97.63 110.9,100.17 111.28,100.55 116.11,100.55 118.02,98.65 119.29,98.65 120.43,97.5 120.43,74.77 119.67,74.01 119.67,57.88 120.43,57.12 120.43,34 120.68,33.75 123.48,33.75 124.24,34.51 127.49,34.51 127.49,35.53 127.57,35.6 127.97,35.6 128.07,35.5 128.07,35.2 128.43,34.84 130.99,34.84 131.12,34.97 131.12,36.21 131.07,36.26 128.96,36.26 128.91,36.32 128.91,36.57 128.96,36.62 130.84,36.62 130.92,36.7 130.92,37.94 130.79,38.07 129.24,38.07 129.17,38.14 129.17,38.35 129.24,38.42 131.83,38.42 132.16,38.09 132.16,37.41 132.24,37.33 132.9,37.33 132.92,37.31 132.92,36.85 132.85,36.77 132.34,36.77 131.71,36.14 131.71,33.88 131.05,33.22 130.69,33.22 128.3,30.83 124.11,30.83 123.48,30.19
GND on BOTTOM: 22.26,44.04 22.13,44.16 22.13,44.67 22.77,45.31 23.04,45.31 23.21,45.48 23.21,46.76 23.02,46.96 22.77,46.96 22.64,47.08 22.64,47.34 22.77,47.47 23.91,47.47 24.54,46.83 25.94,46.83 26.13,46.64 26.13,45.95 24.22,44.04
GND on BOTTOM: 43.72,51.4 43.59,51.53 43.59,55.59 42.58,56.61 42.58,61.69 42.7,61.82 44.86,61.82 44.99,61.69 44.99,61.18 44.36,60.55 44.36,59.91 44.48,59.78 44.99,59.78 45.12,59.66 45.12,56.1 45.88,55.34 45.88,53.05 44.86,52.04 44.86,51.78 44.48,51.4 ; 2 cut-outs
GND on BOTTOM: 11.59,68.04 11.34,68.29 11.34,70.33 10.45,71.21 9.43,71.21 8.92,70.71 2.32,70.71 2.19,70.83 2.19,71.09 2.06,71.21 0.92,71.21 0.79,71.34 0.79,74.26 1.05,74.52 3.72,74.52 3.84,74.39 3.84,73.25 4.35,72.74 6.38,72.74 7.27,71.85 11.79,71.85 12.55,71.09 12.99,71.09 14,70.07 18.7,70.07 18.83,69.94 18.83,68.42 18.45,68.04 ; 4 cut-outs
GND on BOTTOM: 2.45,36.16 2.32,36.29 2.32,37.31 2.45,37.43 11.84,37.43 12.61,38.19 12.61,39.85 13.62,40.86 13.62,41.62 13.88,41.88 14.76,41.88 15.4,41.24 16.03,41.24 16.16,41.12 16.16,40.86 16.03,40.73 15.53,40.73 15.27,40.48 15.27,39.34 16.16,38.45 19.97,38.45 20.23,38.19 20.23,37.56 20.1,37.43 15.65,37.43 14.38,36.16 ; 3 cut-outs
GND on BOTTOM: 93.5,58.51 92.23,59.78 92.23,60.04 92.87,60.67 92.87,62.45 92.49,62.83 92.49,65.12 92.87,65.5 92.87,66.52 92.23,67.15 92.23,67.91 92.49,68.17 92.49,69.18 93.12,69.82 100.74,69.82 101.51,69.06 101.51,67.02 101.12,66.64 95.16,66.64 94.77,66.26 94.77,58.9 94.39,58.51
GND on BOTTOM: 41.41,74.66 40.93,75.15 37.75,75.15 37.62,75.28 37.62,76.29 37.88,76.55 40.8,76.55 40.93,76.68 40.93,78.33 41.31,78.71 43.72,78.71 43.85,78.58 43.85,76.42 43.59,76.17 42.58,76.17 42.07,75.66 42.07,74.82 41.91,74.66 ; 1 cut-out
GND on BOTTOM: 64.17,79.22 62.59,80.79 62.59,84.45 62.59,84.45 62.59,84.94 62.66,85.01 64.41,85.01 65.02,85.62 65.52,85.62 65.75,85.39 65.75,84.25 65.66,84.16 64.96,84.16 64.92,84.12 63.63,84.12 63.53,84.02 63.53,81.17 63.91,80.79 65.39,80.79 65.69,80.49 65.69,79.32 65.59,79.22 ; 4 cut-outs
GND on BOTTOM: 136.66,69.69 136.51,69.84 136.51,70.5 136.43,70.58 135.8,70.58 135.67,70.71 135.67,71.21 136.18,71.72 136.18,76.29 136.05,76.42 133.51,76.42 133.38,76.55 133.38,78.83 133.51,78.96 138.72,78.96 138.97,78.71 138.97,76.93 139.22,76.68 139.86,76.68 140.62,75.91 140.62,73.5 140.49,73.37 140.11,73.37 139.99,73.5 139.99,74.8 139.43,75.36 138.51,75.36 138.18,75.02 138.18,74.24 137.32,73.37 137.32,69.82 137.19,69.69 ; 4 cut-outs
GND on BOTTOM: 33.94,90.26 33.56,90.65 33.56,91.28 33.69,91.41 36.99,91.41 37.37,91.03 37.37,90.39 37.24,90.26 ; 1 cut-out
GND on L2VCC: outline of 156 points within 0.51,0.51 166.59,115.49 ; 5 cut-outs
GND on L3: 62.19,90.47 62.39,90.26 62.39,88.77 62.19,88.56 61.91,88.56 61.32,89.15 60.36,89.15 60.36,89.05 59.7,88.39 56.39,88.39 55.99,88.79 55.99,90.21 56.24,90.47
GND on L3: 16.67,82.01 16.8,81.88 16.8,78.58 16.67,78.45 15.75,78.45 15.63,78.58 15.63,81.86 15.78,82.01
GND on L3: 42.96,61.82 45.75,61.82 46.01,61.56 46.01,60.55 45.19,59.73 45.19,56.84 45.55,56.48 46.23,56.48 46.51,56.2 46.51,55.59 45.75,54.83 44.48,54.83 42.7,56.61 42.7,61.56
GND on L3: 56.45,64.76 60.36,64.76 60.61,64.51 60.61,64.1 60.36,63.85 56.45,63.85 56.27,64.03 56.27,64.59
GND on L3: 55.02,73.12 59.98,73.12 60.48,72.61 60.48,71.72 60.23,71.47 55.4,71.47 55.15,71.72 55.15,72.23 54.9,72.48 54.9,72.99
GND on L3: 43.34,35.78 43.09,35.53 39.15,35.53 38.78,35.9 38.78,37.84 39.9,38.96 45.75,38.96 46.13,38.58 46.13,36.16 45.75,35.78
GND on L3: 78.77,70.83 78.9,70.71 79.28,70.71 82.07,67.91 82.07,65.25 81.69,64.86 76.74,64.86 76.49,65.12 76.49,65.75 77.5,66.77 79.66,66.77 80.17,67.28 80.17,68.42 79.79,68.8 79.15,68.8 76.87,71.09 76.87,71.47 77.12,71.72 78.39,71.72 78.77,71.34
GND on L3: 150.91,30.45 150.91,31.08 151.54,31.72 151.54,32.35 151.04,32.86 145.19,32.86 144.81,32.48 144.81,30.83 145.45,30.19 150.65,30.19
GND on L3: outline of 272 points within 0.79,0.51 166.59,115.16
GND on L3: 87.79,71.47 99.35,71.47 99.73,71.09 99.73,70.07 89.69,60.04 88.68,60.04 88.3,59.66 88.3,59.15 87.41,58.26 85.76,58.26 84.77,57.27 84.77,53.08 84.74,53.05 84.36,53.05 84.23,53.18 84.23,54.32 84.11,54.45 84.11,57.5 85.63,59.02 86.14,59.02 86.52,59.4 86.52,61.44 85.88,62.07 85.88,62.45 86.27,62.83 86.27,64.74 85.88,65.12 85.88,69.56
GND on L3: 100.24,107.66 100.74,107.16 100.74,100.68 99.09,99.03 90.58,99.03 90.33,99.28 90.33,101.82 86.9,105.25 86.9,107.16 87.79,108.04 93.5,108.04 93.89,107.66
GND on L3: 123.6,72.74 125.76,72.74 126.14,72.36 129.06,72.36 129.57,71.85 129.57,35.38 128.33,34.13 127.54,34.13 126.91,34.77 123.22,34.77 121.95,33.5 115.48,33.5 111.79,37.18 110.4,37.18 109.76,37.81 109.76,38.7 113.06,42 113.95,42 114.21,42.26 114.21,42.77 113.95,43.02 110.01,43.02 109.63,42.64 109.63,40.48 108.49,39.34 104.43,39.34 103.98,39.78 103.98,41.18 112.17,49.37 112.17,51.02 114.71,53.56 114.71,54.96 118.78,59.02 118.78,60.29 120.68,62.2 120.68,68.29 122.46,70.07 122.46,71.34 123.48,72.36 123.48,72.61
GND on L3: 53.63,88.23 54.13,88.23 55.28,87.09 55.28,83.53 55.53,83.28 58.2,83.28 59.09,82.39 59.6,82.39 59.85,82.14 59.85,80.1 59.21,79.47 54.77,79.47 53.25,80.99 53.25,87.85
GND on L3: 21.88,65.5 22.26,65.5 22.77,64.99 22.77,60.8 22.51,60.55 21.75,60.55 21.62,60.67 21.62,61.18 21.75,61.31 22.26,61.31 22.38,61.44 22.38,62.71 22.26,62.83 21.88,62.83 21.75,62.96 21.75,63.21 21.88,63.34 22.26,63.34 22.38,63.47 22.38,64.61 22.13,64.86 21.88,64.86 21.75,64.99 21.75,65.37
GND on L3: 76.23,56.86 81.57,56.86 81.69,56.74 81.69,52.04 81.57,51.91 81.19,51.91 78.26,54.83 78.26,55.34 77.63,55.97 76.23,55.97 75.98,56.23 75.98,56.61
GND on L3: 130.97,56.1 132.75,56.1 133.26,55.59 133.26,49.12 132.87,48.74 132.87,45.94 134.53,44.29 134.53,42.26 134.91,41.88 135.41,41.88 135.8,41.5 135.8,40.86 135.67,40.73 132.87,40.73 132.62,40.48 130.84,40.48 130.33,40.99 130.33,55.47
GND on L3, L4: 29.12,88.79 31.96,88.79 32.14,88.61 32.14,87.32 31.78,86.96 29.12,86.96 28.86,87.22 28.86,88.54
GND on L3, L4: 21.5,32.35 25.18,32.35 27.85,29.69 27.85,28.67 27.59,28.42 26.45,28.42 23.65,31.21 21.37,31.21 21.24,31.34 21.24,32.1
GND on L3, L4: 54.77,93.44 60.36,93.44 60.87,92.93 60.87,92.04 60.36,91.53 54.9,91.53 54.52,91.92 54.52,93.19
GND on L3, L4: 51.59,73.25 53.5,73.25 53.75,72.99 53.75,71.72 51.34,69.31 50.71,69.31 50.45,69.56 50.45,70.45 51.34,71.34 51.34,72.99
GND on L3, L4: 105.44,109.44 110.01,109.44 110.78,108.68 110.78,106.27 110.52,106.01 103.66,106.01 103.41,106.27 103.41,107.41
GND on L3, L4: 54.13,39.21 54.13,38.58 53.63,38.07 51.47,38.07 51.21,38.32 51.21,39.34 51.59,39.72 53.63,39.72
GND on L3, L4: 20.86,26.76 22,26.76 23.53,25.24 23.53,24.86 22.13,23.46 21.11,23.46 20.23,24.35 20.23,26.13
GND on L3, L4, L6: 33.05,65.88 32.54,65.37 30,65.37 29.62,65.75 29.62,66.9 31.15,68.42 32.93,68.42 33.05,68.29
GND on L3, L6: 48.17,50.01 49.94,50.01 50.32,49.62 50.32,47.97 49.82,47.47 49.82,44.04 49.51,43.73 47.71,43.73 47.33,44.11 47.33,49.17
GND on L4: outline of 84 points within 0.79,36.16 19.34,82.64
GND on L4: 145.32,30.32 150.65,30.32 150.91,30.57 150.91,30.96 151.54,31.59 151.54,32.35 151.04,32.86 145.32,32.86 144.94,32.48 144.94,30.7
GND on L4: 60.48,71.72 60.23,71.47 55.4,71.47 55.15,71.72 55.15,72.23 54.9,72.48 54.9,73.07 55.24,73.41 60.08,73.41 60.48,73.01
GND on L4: 56.45,64.89 60.59,64.89 60.61,64.86 60.61,64.1 60.36,63.85 56.39,63.85 56.22,64.03 56.22,64.66
GND on L4: 29.62,84.04 31.86,84.04 31.99,83.91 31.99,81.58 31.78,81.37 29.62,81.37 29.37,81.63 29.37,83.79
GND on L4: 100.6,107.27 100.72,107.16 100.72,100.58 99.68,99.54 99.6,99.54 99.09,99.03 90.58,99.03 90.2,99.41 90.2,101.95 86.65,105.5 86.65,106.9 87.28,107.54 88.42,107.54 88.93,108.04 93.5,108.04 93.89,107.66 100.24,107.66 100.6,107.3
GND on L4: 76.36,59.02 81.31,59.02 81.69,58.64 81.69,52.16 81.44,51.91 80.93,51.91 76.11,56.74 76.11,58.77
GND on L4: 42.96,61.82 45.75,61.82 46.01,61.56 46.01,60.55 45.24,59.78 45.24,56.74 45.5,56.48 46.26,56.48 46.51,56.23 46.51,55.59 45.75,54.83 44.48,54.83 42.7,56.61 42.7,61.56
GND on L4: 53.63,88.23 54.13,88.23 55.28,87.09 55.28,83.53 55.59,83.22 58.26,83.22 59.09,82.39 59.6,82.39 59.85,82.14 59.85,80.1 59.21,79.47 54.77,79.47 53.25,80.99 53.25,87.85
GND on L4: outline of 225 points within 0.79,0.51 166.59,115.16
GND on L4: 54.77,90.77 61.11,90.77 61.54,91.21 62.27,91.21 62.39,91.09 62.39,89.83 62.27,89.71 62.27,88.6 61.11,87.43 59.76,87.43 59.09,88.11 56.18,88.11 54.64,89.65 54.64,90.65
GND on L4: 44,37.79 44.48,37.31 44.48,36.29 43.97,35.78 43.34,35.78 43.09,35.53 38.98,35.53 38.75,35.76 38.75,37.34 39.2,37.79
GND on L4: 16.67,82.01 16.8,81.88 16.8,78.58 16.67,78.45 15.7,78.45 15.63,78.53 15.63,81.88 15.75,82.01
GND on L4: 113.95,43.02 110.01,43.02 109.63,42.64 109.63,40.61 108.36,39.34 98.97,39.34 97.31,40.99 92.49,40.99 91.98,41.5 91.98,42.89 91.09,43.78 86.9,43.78 85.25,45.43 85.25,45.94 85.5,46.2 85.5,48.86 84.11,50.26 84.11,52.8 84.36,53.05 84.36,54.07 84.11,54.32 84.11,57.88 85.25,59.02 85.25,61.87 86.62,63.24 86.62,65.63 86.39,65.86 86.39,65.88 85.5,65.88 85.25,66.13 85.25,69.31 87.41,71.47 90.96,71.47 92.74,69.69 100.09,69.69 100.74,70.34 100.74,76.38 103.41,79.06 103.41,81.76 107.09,85.44 107.6,85.44 107.73,85.31 108.11,85.31 108.62,85.82 108.62,86.33 108.36,86.58 108.36,86.84 109.51,87.98 111.12,87.98 119.5,96.36 120.43,96.36 121.19,97.12 126.32,97.12 127.29,96.16 128.25,96.16 130.21,94.2 130.21,87.6 129.95,87.34 129.95,35.4 128.68,34.13 127.41,34.13 126.78,34.77 123.22,34.77 121.95,33.5 115.48,33.5 111.79,37.18 110.4,37.18 109.76,37.81 109.76,38.7 113.06,42 113.95,42 114.21,42.26 114.21,42.77
GND on L4: 48.17,50.01 49.94,50.01 50.32,49.62 50.32,47.97 49.82,47.47 49.82,44.04 49.44,43.66 47.78,43.66 47.28,44.16 47.28,49.12
GND on L5GND: outline of 155 points within 0.51,0.51 166.59,115.49 ; 2 cut-outs
GND on L6: 69.76,31.46 74.84,31.46 75.72,30.57 75.72,26.64 70.52,21.43 68.99,21.43 68.36,22.07 68.36,30.07
GND on L6: 17.81,83.03 18.83,82.01 18.83,80.49 16.8,78.45 15.53,78.45 15.27,78.71 15.27,82.52 15.78,83.03
GND on L6: 51.59,73.25 53.5,73.25 53.75,72.99 53.75,71.72 51.34,69.31 48.42,69.31 47.66,70.07 47.66,72.99 47.91,73.25 49.05,73.25 49.18,73.12 49.18,71.6 49.44,71.34 51.21,71.34 51.47,71.6 51.47,73.12
GND on L6: outline of 298 points within 0.79,0.51 165.89,115.16
GND on L6: 55.66,67.53 56.17,68.04 58.96,68.04 59.47,67.53 59.47,66.01 60.36,65.12 60.36,64.61 60.61,64.36 60.61,58.13 61.37,57.37 62.14,57.37 62.26,57.24 62.26,56.99 62.77,56.48 63.91,56.48 64.17,56.23 64.17,55.72 63.66,55.21 53.25,55.21 51.85,53.82 50.45,53.82 49.82,54.45 49.82,55.34 50.45,55.97 54.13,55.97 54.9,56.74 54.9,60.67 55.66,61.44
GND on L6: 80.68,88.61 82.2,88.61 82.58,88.23 82.58,86.71 82.96,86.33 83.47,86.33 83.47,85.95 83.34,85.82 82.96,85.82 82.84,85.69 82.84,84.93 82.33,84.42 80.68,84.42 80.42,84.68 80.42,88.36
GND on L6: 28.86,88.11 31.78,88.11 32.54,87.34 32.54,82.14 31.91,81.5 28.73,81.5 28.23,82.01 28.23,87.47
GND on L6: 53.63,88.23 54.13,88.23 55.28,87.09 55.28,83.53 55.53,83.28 58.2,83.28 59.09,82.39 59.6,82.39 59.85,82.14 59.85,79.85 58.96,78.96 53.88,78.96 53.25,79.6 53.25,87.85
GND on L6: 134.53,44.16 134.53,42.26 134.91,41.88 135.41,41.88 135.8,41.5 135.8,40.86 135.67,40.73 134.02,40.73 133.76,40.48 131.6,40.48 130.97,41.12 130.97,58.13 131.48,58.64 132.11,58.64 132.75,59.28 135.16,59.28 136.49,57.94 136.49,55.15 134.65,53.31 134.65,44.29
GND on L6: 20.86,26.76 22,26.76 23.53,25.24 23.53,24.1 22.89,23.46 20.73,23.46 20.23,23.97 20.23,26.13
GND on L6: 128.43,95.47 129.19,94.71 129.19,83.66 129.16,83.63 129.16,80.14 128.97,79.95 127.03,79.95 126.13,80.84 115.12,80.84 114.59,81.37 114.59,86.84 121.83,94.07 121.83,94.96 122.33,95.47
GND on L6: 31.4,96.23 32.42,96.23 32.8,95.85 32.8,93.57 32.04,92.8 28.73,92.8 27.72,93.82 26.83,93.82 26.7,93.95 26.7,94.71 26.83,94.84 28.35,94.84 29.37,95.85 31.02,95.85
GND on L6: 42.96,61.82 45.75,61.82 46.01,61.56 46.01,60.55 45.19,59.73 45.19,56.84 45.55,56.48 46.23,56.48 46.51,56.2 46.51,55.59 45.75,54.83 44.74,54.83 42.7,56.86 42.7,61.56
GND on L6: 145.19,30.32 150.45,30.32 150.6,30.47 150.6,32.73 150.48,32.86 145.07,32.86 144.81,32.61 144.81,30.7
GND on L6: 60.23,72.87 60.23,71.85 59.85,71.47 55.4,71.47 55.15,71.72 55.15,72.23 54.77,72.61 54.77,74.9 55.02,75.15 59.21,75.15 59.6,74.77 59.6,73.5
GND on L6: 83.47,99.5 83.47,104.49 85.12,106.14 85.12,107.28 84.74,107.66 84.74,108.04 85.88,109.19 95.79,109.19 95.92,109.31 101.51,109.31 102.01,108.81 105.06,108.81 105.57,109.31 109.38,109.31 109.89,108.81 109.89,104.87 108.74,103.73 108.74,102.33 107.43,101.02 104.86,101.02 104.64,101.24 104.64,103.3 104.47,103.46 103.18,103.46 99.06,99.35 83.63,99.35
GND on L6: 65.31,85.68 65.31,82.26 64.42,81.37 64.04,81.37 63.53,81.88 62.64,81.88 62.39,82.14 62.39,85.66 62.57,85.83 65.16,85.83
GND on L6: 56.17,94.07 60.41,94.07 60.68,93.8 60.68,92.42 60.43,92.17 56.17,92.17 55.91,92.42 55.91,93.82
GND on L7GND: outline of 164 points within 0.51,0.51 166.59,115.49 ; 2 cut-outs
VCC_CORE on TOP: outline of 85 points within 46.9,57.63 86.52,71.09 ; 54 cut-outs
VCC_CORE on BOTTOM: 84.36,60.42 84.11,60.67 83.6,60.67 83.47,60.8 83.47,61.31 83.6,61.44 83.98,61.44 84.11,61.56 84.11,61.94 83.85,62.2 83.6,62.2 83.47,62.32 83.47,64.48 83.73,64.74 84.74,64.74 84.87,64.86 84.87,64.99 85.12,65.25 85.12,65.5 85.5,65.88 86.01,65.88 86.14,65.75 86.14,65.63 86.44,65.32 86.44,65.04 85.88,64.48 85.25,64.48 85.12,64.36 85.12,64.1 85.25,63.98 85.99,63.98 86.42,63.54 86.42,63.16 85.96,62.71 85.35,62.71 85.12,62.48 85.12,62.32 85.25,62.2 85.88,62.2 86.01,62.07 86.01,61.82 85.85,61.65 85.85,61.42 85.62,61.19 85.62,61.04 85.38,60.8 85.22,60.8 85.12,60.7 85.12,60.55 85,60.42
VCC_CORE on BOTTOM: 75.35,58.75 75.35,58.75 74.32,58.75 74.1,58.97 74.1,59.37 74.19,59.45 74.19,59.7 74.03,59.85 73.5,59.85 73.49,59.85 73.21,60.13 73.21,60.24 73.08,60.37 73.08,60.78 73.21,60.9 73.21,61.16 73.11,61.26 73.11,61.66 73.21,61.77 73.21,62.1 73.08,62.22 73.08,62.63 73.21,62.76 73.21,65.75 72.98,65.98 72.98,66.3 73.44,66.76 73.85,66.76 73.86,66.76 73.96,66.76 74.45,66.26 74.45,65.94 74.45,65.94 74.45,65.83 73.81,65.2 73.81,65.03 73.96,64.88 74.69,64.88 74.84,64.74 75.72,64.74 75.98,64.48 75.98,59.01 75.72,58.75
VCC_CORE on BOTTOM: 69.78,58.54 69.68,58.64 67.34,58.64 67.09,58.9 67.09,61.56 67.22,61.69 69.37,61.69 69.63,61.44 69.94,61.44 70.09,61.29 70.09,61.07 70,60.98 69.56,60.98 68.87,60.29 68.87,59.66 69.4,59.12 69.7,59.12 70.09,58.74 70.09,58.64 69.98,58.54
VCC_CORE on BOTTOM: 47.28,61.05 46.9,61.44 46.9,65.75 47.53,66.39 47.53,67.91 47.78,68.17 53.63,68.17 54.26,68.8 54.26,69.56 55.15,70.45 64.68,70.45 64.93,70.2 65.31,70.2 69.25,66.26 70.01,66.26 70.14,66.13 70.14,65.75 70.01,65.63 69.5,65.63 69.37,65.5 69.37,65.25 69.45,65.17 70.11,65.17 70.26,65.02 70.26,64.71 70.11,64.56 69.48,64.56 69.37,64.46 69.37,64.1 69.76,64.1 70.14,63.72 70.14,63.59 70.01,63.47 68.74,63.47 65.82,66.39 63.41,66.39 63.15,66.64 63.15,67.66 62.39,68.42 55.66,68.42 55.28,68.04 55.28,64.1 54.77,63.59 54.77,61.44 54.39,61.05 51.98,61.05 51.09,61.94 49.82,61.94 49.56,61.69 49.56,61.31 49.31,61.05
VCC_CORE on L2VCC: 51.42,56.93 50.9,57.45 50.9,58.97 50.02,59.85 46.59,59.85 45.82,60.63 45.82,64.53 49.77,68.48 52.05,68.48 53.83,70.26 62.44,70.26 65.49,67.21 68.66,67.21 69.3,66.58 69.55,66.58 71.71,64.42 81.87,64.42 82.26,64.02 82.26,58.59 81.23,57.56 65.39,57.56 65.26,57.69 59.01,57.69 58.25,56.93
VCC_CORE on L3: 54.2,56.67 53.63,57.24 53.63,59.28 51.85,61.05 47.02,61.05 46.77,61.31 46.77,66.52 49.05,68.8 51.34,68.8 52.86,70.33 62.9,70.33 65.69,67.53 68.87,67.53 71.66,64.74 81.44,64.74 82.2,63.98 82.2,58.9 81.19,57.88 76.74,57.88 76.11,58.51 74.07,58.51 73.69,58.13 71.28,58.13 70.01,56.86 65.44,56.86 64.8,56.23 61.37,56.23 60.23,57.37 59.09,57.37 58.39,56.67 ; 1 cut-out
VCC_CORE on L4: 76.11,59.15 84.36,59.15 85,59.78 85,61.82 86.52,63.34 86.52,65.25 86.27,65.5 85.38,65.5 85,65.12 85,64.86 84.74,64.61 84.11,64.61 83.34,63.85 76.49,63.85 75.85,64.48 71.91,64.48 69.37,67.02 66.71,67.02 66.33,66.64 66.33,59.4 67.47,58.26 71.41,58.26 71.53,58.13 75.09,58.13
VCC_CORE on L4: 63.02,70.96 63.79,70.2 63.79,63.59 62.14,61.94 56.67,61.94 55.91,61.18 52.23,61.18 51.85,61.56 50.07,61.56 49.18,60.67 47.4,60.67 46.9,61.18 46.9,65.12 49.94,68.17 51.09,68.17 53.88,70.96 ; 1 cut-out
VCC_CORE on L6: 84.33,64.61 84.61,64.61 84.87,64.36 84.87,63.32 84.16,62.6 84.16,61.05 83.93,60.83 83.62,60.83 83.09,60.29 83.09,59.02 82.46,58.39 77.25,58.39 76.87,58.77 75.09,58.77 73.82,60.04 72.93,60.04 72.17,60.8 72.17,61.82 71.41,62.58 71.41,66.77 72.17,67.53 74.2,67.53 74.58,67.15 74.58,66.77 74.71,66.64 76.11,66.64 76.36,66.9 78.77,66.9 79.03,66.64 82.84,66.64 83.6,65.88 83.6,65.35
VCC_CORE on L6: 59.6,70.96 59.98,70.58 59.98,68.67 59.6,68.29 55.66,68.29 55.28,67.91 55.28,61.69 54.26,60.67 52.36,60.67 51.47,61.56 50.07,61.56 49.18,60.67 47.4,60.67 46.9,61.18 46.9,65.63 49.82,68.55 50.96,68.55 53.37,70.96
0D675V_PWR on TOP: 132.49,73.37 132.37,73.5 132.37,74.9 131.6,75.66 131.6,76.55 131.73,76.68 133.89,76.68 134.02,76.55 134.02,75.79 133.89,75.66 133.89,73.5 133.76,73.37 ; 2 cut-outs
0D675V_PWR on BOTTOM: 132.75,73.25 132.37,73.63 132.37,75.66 132.49,75.79 133.89,75.79 133.89,73.63 134.02,73.5 134.53,73.5 134.65,73.63 134.65,75.79 134.91,75.79 134.91,73.5 134.65,73.25
0D675V_S0 on TOP: 131.73,77.18 131.6,77.31 131.6,79.09 129.45,81.25 129.45,95.98 128.56,96.87 123.98,96.87 123.48,97.38 123.48,98.9 123.6,99.03 124.87,99.03 125.38,98.52 126.14,98.52 126.65,99.03 128.3,99.03 130.72,96.61 130.72,82.01 134.02,78.71 134.02,77.31 133.89,77.18 ; 5 cut-outs
1D0V_S5 on TOP: 63.74,90.13 63.7,90.18 63.7,92.4 63.46,92.64 62.99,92.64 62.83,92.8 62.83,94.45 62.95,94.56 63.75,94.56 63.81,94.5 63.81,93.56 63.99,93.38 65.75,93.38 65.98,93.15 65.98,92.82 65.85,92.68 65.46,92.68 65.33,92.55 65.33,90.16 65.31,90.13
1D0V_S5 on TOP: 70.52,91.03 70.39,91.15 70.39,91.66 70.26,91.79 69.76,91.79 69.5,92.04 69.5,92.93 69.88,93.31 70.52,93.31 70.77,93.57 71.79,93.57 72.17,93.19 72.17,91.79 71.41,91.03 ; 3 cut-outs
1D0V_S5 on TOP: 55.71,83.64 55.53,83.81 55.53,85.31 55.66,85.44 55.66,86.94 55.79,87.06 59.42,87.06 59.67,87.32 60.89,87.32 61.02,87.45 61.02,88.41 61.09,88.49 62.16,88.49 62.41,88.74 63.02,88.74 63.23,88.54 63.23,87.88 63.79,87.32 63.81,87.32 63.89,87.24 63.89,86 63.79,85.9 62.41,85.9 62.11,85.59 59.72,85.59 59.57,85.44 59.57,84.12 59.09,83.64 ; 2 cut-outs
1D0V_S5 on TOP: 82.84,71.47 82.71,71.6 82.71,73.5 83.09,73.88 84.23,73.88 84.49,73.63 84.49,72.48 84.36,72.36 84.36,71.98 84.11,71.72 83.6,71.72 83.34,71.47 ; 3 cut-outs
1D0V_S5 on TOP: 78.9,70.83 78.77,70.96 78.77,71.34 78.52,71.6 78.52,72.23 78.65,72.36 78.9,72.36 79.15,72.1 79.66,72.1 79.79,71.98 79.79,71.6 79.66,71.47 79.41,71.47 79.28,71.34 79.28,70.96 79.15,70.83
1D0V_S5 on BOTTOM: 107.86,33.37 107.35,33.88 107.35,36.92 103.92,40.35 103.92,43.4 104.2,43.68 104.2,65.25 106.33,67.38 106.33,81.25 105.44,82.14 105.44,86.58 104.49,87.53 104.49,89.82 103.28,91.03 100.87,91.03 98.71,93.19 95.54,93.19 94.52,94.2 94.52,95.73 94.27,95.98 93.89,95.98 93.5,96.36 93.5,97.25 94.01,97.76 96.68,97.76 97.38,97.06 98.27,97.06 100.04,95.28 100.04,94.14 101.89,92.3 104.05,92.3 105.95,90.39 105.95,88.06 106.59,87.42 106.59,82.9 107.35,82.14 107.35,66.77 105.19,64.61 105.19,43.15 104.93,42.89 104.93,41.12 108.49,37.56 108.49,33.75 108.11,33.37
1D0V_S5 on BOTTOM: 51.76,82.39 51.67,82.49 51.67,86.22 51.71,86.26 55.21,86.26 55.4,86.45 58.58,86.45 58.96,86.07 59.98,86.07 60.23,86.33 60.23,87.32 60.33,87.42 61.91,87.42 62.14,87.65 62.14,88.74 62.9,89.5 63.15,89.5 63.28,89.38 63.91,89.38 64.17,89.63 64.17,93.06 64.29,93.19 65.82,93.19 66.33,92.68 67.34,92.68 67.6,92.93 70.52,92.93 71.15,92.3 71.15,91.15 69.88,89.88 67.09,89.88 66.45,89.25 66.45,87.34 64.56,85.45 62,85.45 61.45,84.91 61.45,83.53 61.53,83.46 62.39,83.46 62.39,82.7 62.29,82.59 60.97,82.59 60.89,82.67 59.24,82.67 58.96,82.39 ; 2 cut-outs

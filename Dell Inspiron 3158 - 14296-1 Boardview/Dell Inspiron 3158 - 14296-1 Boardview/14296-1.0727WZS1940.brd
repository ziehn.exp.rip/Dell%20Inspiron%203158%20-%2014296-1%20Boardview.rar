# Allegro board 14296-1.0727WZS1940.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_CPU_PP2: length 119.1
  TOP w0.102: TR6601.3 155.95,62.64 155.61,62.98 155.61,63.45 v2(155.8,63.64)
  L6 w0.102: v2(155.8,63.64) 155.8,64.47 155.75,64.52 155.34,64.93 151.25,64.93 150.6,65.58 149.59,65.58 148.5,66.67 148.5,67.46 144.99,70.96 143.72,70.96 142.13,72.55 141.7,72.55 139.87,74.38 139.87,74.39 137.86,76.41 137.86,82.73 136.77,83.82 136.77,86.48 136.16,87.09 136.16,88.97 135.42,89.71 135.42,96.79 129.7,102.51 129.34,102.51 128.4,103.45 119.15,103.45 118.55,103.45 110.06,94.96 109.37,94.96 108.29,93.88 108.28,93.88 105.55,91.15 104.19,91.15 102.52,89.49 102.52,87.86 100.4,85.74 99.51,85.74 98.03,84.26 92.97,84.26 91.6,85.62 87.68,85.62 85.7,87.61 84.85,87.61 83.73,86.48 83.73,85.85 v2(83.25,85.37)
  BOTTOM w0.089: 84.19,84.45 84.19,84.43 84.18,84.42 84.15,84.25 84.15,83.69 84.09,83.57 84.09,83.42 84.15,83.29 84.15,83.04 84.09,82.92 84.09,82.77 84.15,82.64 84.26,82.53 85.02,82.53 CPU1.AJ3
  BOTTOM w0.102: v2(83.25,85.37) 83.89,85.37 84.21,85.06 84.21,84.56 84.19,84.45 ; v2(155.8,63.64) 155.48,63.32 v1(155.48,62.96)
USB_CPU_PP2_C: length 20.8
  TOP w0.102: v2(155.84,60.13) 155.95,60.23 TR6601.4
  BOTTOM w0.102: 155.61,58.51 155.61,57.81 154.24,56.45 153.08,56.45 150.58,53.95 150.58,51.47 148.81,49.7 146.95,49.7 145,47.75 IOBD1.7 ; 155.61,58.51 155.61,59.89 v2(155.84,60.13) ; 155.61,58.51 v1(155.81,58.51)
USB_CPU_PP3: length 30.2
  TOP w0.102: v1(82.15,104.08) 82.3,104.23 v2(82.71,104.23) 82.84,104.11 R6906.1
  L3 w0.102: v2(82.71,104.23) 83.17,103.78 83.17,103.2 81.95,101.98 81.95,92.23 82.53,91.65 82.53,90.43 81.67,89.57 81.67,86.63 82.33,85.98 82.33,83 82.05,82.72 82.05,81.47 81.73,81.15 81.73,80.42 81.73,80.41 81.73,79.84 81.72,79.84 81.72,78.88 v2(82.39,78.21)
  BOTTOM w0.102: CPU1.AD10 82.12,78.48 v2(82.39,78.21)
USB_CPU_PP4: length 53.8
  TOP w0.102: v2(58.45,101.31) 58.07,100.93 58.07,100.38 TR5501.1
  L3 w0.102: v2(85.11,85.64) 84.91,85.84 84.54,86.21 84.54,87.32 84.54,89.81 84.16,90.19 84.16,91.46 85.12,92.42 85.12,94 84.16,94.96 84.16,97.6 85.99,99.43 85.99,100.06 v2(86.22,100.3)
  BOTTOM w0.102: 61.17,100.6 60.01,100.6 59.78,100.37 58.52,100.37 58.17,100.72 58.17,101.03 v2(58.45,101.31) ; 61.17,100.6 v1(61.17,100.78) ; 61.17,100.6 62.24,100.6 62.77,101.14 64.6,101.14 66.13,99.61 69.79,99.61 70.35,99.05 75.67,99.05 76.35,99.74 81.1,99.74 82.8,101.44 85.66,101.44 86.22,100.88 v2(86.22,100.3) ; CPU1.AJ2 85.03,83.31 85.32,83.61 85.32,83.62 86.09,84.38 86.09,85.21 85.66,85.64 v2(85.11,85.64)
USB_CPU_PP5: length 108.9
  TOP w0.102: R6606.2 150.45,62.34 150.45,63.29 v2(150.27,63.47)
  L6 w0.102: v2(83.45,80.77) 83.83,81.15 83.83,81.81 84.82,82.8 88.33,82.8 88.34,82.81 90.81,82.81 91.36,82.26 98.31,82.26 98.49,82.26 98.98,82.75 100.25,82.75 101.98,84.47 101.98,85.49 104.82,88.34 104.82,89.09 108.67,92.94 108.78,92.94 109.86,94.02 110.45,94.02 118.94,102.51 128.01,102.51 128.95,101.57 129.22,101.57 129.27,101.57 134.44,96.4 134.44,89.34 135.21,88.56 135.21,86.72 135.83,86.09 135.83,83.42 136.86,82.4 136.86,76.08 138.93,74 138.93,73.96 141.29,71.6 141.64,71.6 143.22,70.02 144.6,70.02 147.48,67.15 147.48,66.35 149.23,64.6 150.25,64.6 150.62,64.23 150.69,64.16 150.69,63.9 150.27,63.48 v2(150.27,63.47)
  BOTTOM w0.102: v1(150.63,64.05) 150.27,63.7 v2(150.27,63.47) ; CPU1.AF7 v2(83.45,80.77)
USB_CPU_PP5_C: length 15.8
  TOP w0.102: v2(150.32,60.13) 150.48,60.28 150.48,60.76 R6606.1
  BOTTOM w0.102: IOBD1.14 144.58,51.25 144.78,51.05 146.2,51.05 146.48,51.33 148.14,51.33 148.95,52.14 148.95,55.21 150.65,56.91 150.65,58.46 ; v2(150.32,60.13) 150.33,60.13 150.65,59.8 150.65,58.46 ; v1(150.48,58.46) 150.65,58.46
USB_CPU_PP6: length 80.6
  TOP w0.102: R5511.2 31.17,101.57 31.78,101.57 v2(31.91,101.44)
  L3 w0.102: v2(84.12,100.3) 84.5,100.56 84.52,100.59 84.52,100.92 84.22,101.21 83.91,101.21 83.44,100.74 83.44,95.79 82.86,95.21 82.86,92.61 83.44,92.03 83.44,90.05 82.59,89.2 82.59,87.26 82.73,87.12 83.07,87.12 v2(83.27,87.31)
  BOTTOM w0.102: 41.03,102.46 36.92,102.46 36.34,101.87 32.36,101.87 31.93,101.44 v2(31.91,101.44) ; 41.03,102.46 48.17,102.46 51.77,98.85 60.08,98.85 60.08,98.85 60.25,98.85 61.09,99.69 61.68,99.69 61.68,99.69 64.31,99.69 65.31,98.69 69.05,98.69 69.68,98.06 76.15,98.06 76.91,98.82 80.72,98.82 81.57,98.82 83.27,100.53 83.9,100.53 v2(84.12,100.3) ; 41.03,102.46 v1(41.03,102.25) ; v2(83.27,87.31) 83.63,87.31 83.78,87.17 83.78,86.46 84.69,85.54 84.69,83.16 CPU1.AH2
USB_CPU_PP7: length 113.5
  TOP w0.102: v2(153.36,63.64) 153.19,63.48 153.19,62.96 153.41,62.75 TR6602.3
  L6 w0.102: v2(83.39,79.5) 83.48,79.58 84.03,79.58 84.9,80.45 84.9,81.08 85.9,82.08 88.63,82.08 88.64,82.08 90.51,82.08 91.09,81.5 98.76,81.5 99.28,82.02 100.55,82.02 102.7,84.17 102.7,85.07 103.74,86.12 103.74,86.2 103.99,86.45 104.08,86.45 105.54,87.92 105.54,88.79 108.97,92.22 110.53,92.22 113.36,95.05 113.36,95.9 119.24,101.78 127.71,101.78 128.65,100.84 128.95,100.84 133.53,96.26 133.53,87.37 135.11,85.79 135.11,83.03 136.13,82.01 136.13,77.31 136.13,77.31 136.13,75.78 138.21,73.7 138.21,72.99 141.26,69.94 141.51,69.94 142.16,69.3 144.3,69.3 146.75,66.85 146.75,66.05 148.81,64 148.81,63.1 149.29,62.62 153.11,62.62 153.36,62.87 v2(153.36,63.64)
  BOTTOM w0.102: v2(153.36,63.64) 153.7,63.3 v1(153.7,63.16) ; CPU1.AF9 83.27,79.5 v2(83.39,79.5)
USB_CPU_PP7_C: length 17.9
  TOP w0.102: TR6602.4 153.41,60.18 v2(153.35,60.13)
  BOTTOM w0.102: 153.11,58.82 153.11,58.54 151.97,57.41 151.97,56.35 149.87,54.24 149.87,51.76 148.52,50.41 146.66,50.41 145.57,49.32 144.76,49.32 144.69,49.25 IOBD1.10 ; 153.11,58.82 v1(153.27,58.82) ; 153.11,58.82 153.11,59.88 v2(153.35,60.13)
USB_EN#: length 2.9
  TOP w0.102: KBC24.13 161.05,46.07 v1(161.73,45.39) 161.91,45.39 162.34,44.96 R2479.1
USB_OC0#: length 145.1
  L3 w0.102: v2(22.37,56.69) 22.43,56.69 23.91,55.21 v2(25.94,55.21)
  L4 w0.102: v2(66,78.33) 66,78.28 64.03,76.31 61.77,76.31 61.47,76.6 61.47,82.52 60.79,83.2 60.79,87.36 62.45,89.03 62.45,89.65 62.67,89.87 62.67,91.18 61.89,91.95 61.89,93.88 60.85,94.93 44.72,94.93 43.95,95.7 42.15,95.7 40.28,93.82 35.48,93.82 34.26,95.04 32.26,95.04 30,97.3 26.01,97.3 25.37,96.67 21.66,96.67 21.3,96.67 18.53,93.9 18.08,93.9 12.3,88.12 12.3,79.62 13.09,78.83 13.09,77.89 12.2,77 12.2,74.97 13.06,74.11 13.06,72.49 13.7,71.85 13.7,71.18 14.22,70.65 14.24,70.6 14.24,67.32 14.78,66.77 14.78,64.72 16.01,63.5 16.01,58.05 15.4,57.44 v2(15.4,56.61)
  BOTTOM w0.102: U3401.13 25.8,55.07 v2(25.94,55.21) ; CPU1.A9 69.12,79.63 67.3,79.63 v1(66.51,78.84) v2(66,78.33) 66,78.17 65.56,77.74 65.56,77.11 65.18,76.72 RN1601.6 ; U3501.3 22.51,50.92 21.34,52.09 19.72,52.09 19.21,52.6 18.61,52.6 18.14,53.07 18.14,55.4 17.3,56.23 15.78,56.23 v2(15.4,56.61) 15.69,56.9 19.17,56.9 19.64,57.37 20.99,57.37 21.09,57.27 21.79,57.27 v2(22.37,56.69)
USB_OC1#: length 166.4
  L3 w0.102: v2(158.02,60.86) 158.02,62.58 156.14,64.46 155.15,64.46 148.78,70.83 147.84,70.83 147.79,70.87 v2(147.73,70.87)
  L4 w0.102: v2(147.73,70.87) 147.67,70.87 147.63,70.83 145.53,70.83 144.6,71.75 143.45,71.75 142.68,72.51 142.68,73.38 139.51,76.55 139.09,76.55 138.08,77.56 138.08,81.49 136.56,83.01 136.56,90.01 135.73,90.84 135.73,96.38 133.56,98.55 133.56,99.91 130.96,102.51 129.34,102.51 128.38,103.47 124.85,103.47 124.7,103.63 115.93,103.63 111.55,99.24 111.55,98.87 111.15,98.47 109.27,98.47 108.7,99.05 104.42,99.05 103.03,97.66 99.68,97.66 97.44,95.42 96.5,95.42 96.25,95.67 96.25,97.12 95.31,98.06 83.94,98.06 81.33,95.45 76.52,95.45 75.68,96.29 74.18,96.29 73.58,95.69 70.95,95.69 68.04,92.78 67.19,92.78 66.86,92.46 66.86,89.05 66.53,88.72 66.53,84.12 66.76,83.89 66.76,82.82 66.55,82.62 66.55,79.9 66.12,79.47 v2(66.1,79.47)
  BOTTOM w0.089: CPU1.C9 70.65,79.16 70.39,79.42 70.15,79.42 69.88,79.7
  BOTTOM w0.102: v2(158.02,60.86) 157.47,61.41 v1(153.96,61.41) 151.9,61.41 151.61,61.12 148.09,61.12 146.72,59.75 IOBD1.31 ; 69.88,79.7 69.76,79.82 66.45,79.82 v2(66.1,79.47) 66.07,79.44 66.07,79.11 64.76,77.8 RN1601.5
USB_OC2#: length 9.2
  BOTTOM w0.089: 68.28,78.99 68.34,79.04 69.04,79.04 69.36,78.73 69.68,78.73 arc(69.72,78.73) 69.76,78.74 69.82,78.76 70.14,78.76 70.2,78.83 71.2,78.83 71.53,79.16 CPU1.D9
  BOTTOM w0.102: RN1601.8 65.35,75.57 v1(65.76,75.98) 66.24,76.47 66.24,77.58 66.59,77.93 66.59,78.02 67.33,78.76 68.05,78.76 68.28,78.99
USB_OC3#: length 173.4
  TOP w0.102: v2(148.81,69.12) 149.17,69.12 v1(149.48,68.81) ; R2457.2 162.6,43.29 v2(161.47,44.41)
  L3 w0.102: v2(148.81,69.12) 150.18,69.12 155.12,64.18 156.04,64.18 157.14,63.08 157.14,58.27 157.81,57.6 157.81,55.61 156.5,54.29 156.5,50.39 156.02,49.91 156.02,47.39 v2(156.43,46.98)
  L4 w0.102: v2(67.85,79.22) 67.93,79.29 67.93,81.55 67.7,81.78 67.7,84.28 68.12,84.7 68.35,84.7 68.66,85.01 68.66,85.46 68.22,85.9 68.22,86.42 68.13,86.51 68.13,88.18 67.66,88.65 67.66,90.63 68.51,91.48 68.51,92.67 71.12,95.28 73.75,95.28 74.35,95.88 75.51,95.88 76.35,95.04 81.5,95.04 84.11,97.65 94.55,97.65 95.01,97.19 95.01,95.62 95.82,94.81 97.54,94.81 99.98,97.25 103.2,97.25 104.59,98.65 108.53,98.65 109.11,98.07 111.91,98.07 117.03,103.18 123.79,103.18 124.01,102.96 127.9,102.96 128.87,101.99 129.48,101.99 132.9,98.57 132.9,98.16 134.91,96.16 134.91,90.65 136.05,89.5 136.05,82.67 137.45,81.27 137.45,76.52 140.24,73.72 140.24,72.99 142.13,71.11 143.54,71.11 145.53,69.12 v2(148.81,69.12)
  BOTTOM w0.089: CPU1.B9 70.09,79.02 arc(70.03,78.98) 69.95,78.96 69.91,78.96 arc(69.87,78.96) 69.84,78.95 69.82,78.94 69.8,78.94 arc(69.79,78.94) 69.78,78.93 69.73,78.92 arc(69.69,78.91) 69.65,78.9 69.47,78.9 arc(69.43,78.91) 69.4,78.93 69.12,79.22 v2(67.85,79.22)
  BOTTOM w0.102: v2(161.47,44.41) 158.42,47.47 156.92,47.47 v2(156.43,46.98) ; v2(67.85,79.22) 67.47,79.22 66.4,78.15 66.4,78.01 65.95,77.55 65.95,76.93 65.24,76.22 RN1601.7
USB_PN0_R: length 5.3
  BOTTOM w0.102: 23.63,59.02 23.63,56.66 23.78,56.51 U3401.11 ; 23.63,59.02 v1(23.78,59.02) ; 23.63,59.02 23.63,59.18 23.32,59.48 22.89,59.48 22.63,59.74 TR3602.1
USB_PN6_TPNL: length 2.4
  TOP w0.102: v2(28.35,102.28) 28.51,102.13 29.14,102.13 R5510.1
  BOTTOM w0.102: v2(28.35,102.28) 28.53,102.1 28.84,102.1 28.99,102.25 HOMBD1.15
USB_PP0_R: length 4.9
  BOTTOM w0.102: 23.43,57.63 23.43,59.09 23.24,59.28 22.89,59.28 22.68,59.06 22.12,59.06 TR3602.4 ; 23.43,57.63 23.43,56.68 23.28,56.53 U3401.10 ; 23.43,57.63 v1(23.27,57.63)
USB_PP6_TPNL: length 2.4
  TOP w0.102: v2(28.35,101.57) 29.09,101.57 R5511.1
  BOTTOM w0.102: v2(28.35,101.57) 28.68,101.9 28.91,101.9 29.06,101.75 HOMBD1.14
USB_PWR_EN#: length 228.6
  TOP w0.102: v1(164.7,58.7) 164.19,58.7 v2(164.14,58.64) ; v2(164.31,45.85) R2434.2 R2479.2
  L3 w0.102: v2(25.69,47.97) 24.62,46.91 24.62,45.57 35.85,34.33 43.48,34.33 43.87,34.72 78.41,34.72 81.87,31.26 83.47,31.26 87.36,27.37 95.38,27.37 98.46,24.3 105.44,24.3 106.46,23.29 108.62,23.29 108.98,23.65 110.37,23.65 110.83,24.1 117.12,24.1 118.17,23.06 121.6,23.06 123.15,21.51 126.68,21.51 126.88,21.71 128.67,21.71 129.57,20.81 130.21,20.81 130.8,21.4 130.8,23.04 131.8,24.03 132.5,24.03 136.38,27.91 136.38,28.93 141.58,34.13 142.84,34.13 v2(143.47,34.76)
  L4 w0.102: v2(163.01,27.85) 163.01,29.35 162.3,30.06 161.51,30.06 158.98,32.58 158.98,33.65 158.69,33.94 157.6,33.94 157.12,33.46 157.12,33.33 156.8,33.01 153.5,33.01 153.48,33.04 150.13,33.04 149.94,32.84 146.85,32.84 144.5,35.19 143.9,35.19 v2(143.47,34.76) ; v2(164.14,58.64) 164.14,58.62 164.57,58.19 164.57,57.83 164.43,57.68 164.43,47.25 164.31,47.12 v2(164.31,45.85)
  L6 w0.102: v2(163.01,27.85) 163.3,27.56 163.64,27.56 164.69,28.6 164.69,35.67 163.94,36.42 163.94,45 163.94,45 163.94,45.36 163.94,45.36 163.94,45.49 v2(164.31,45.85)
  BOTTOM w0.102: v2(164.14,58.64) 162.57,60.22 157.69,60.22 156.99,60.92 148.36,60.92 146.69,59.25 IOBD1.30 ; v2(25.69,47.97) 25.24,47.53 24.23,47.53 23.46,48.29 23.46,49.75 24.29,50.57 U3501.4
USB_UART_SEL_D9: length 4.7
  BOTTOM w0.089: CPU1.P2 77.27,83.36 77.27,83.58 77.34,83.71 77.34,83.97 77.14,84.17 77.14,85.55 76.99,85.7 76.99,86.33 TP2006.1
USBCHARGER_CB0: length 177
  TOP w0.102: v1(20.99,54.91) v2(20.99,54.32) ; R2473.1 156.31,36.93 v2(156.31,37.49) 156.07,37.73 155.69,37.73 155.68,37.74 155.64,37.74 155.63,37.74 155.58,37.74 155.33,37.99 155.33,38.28 154.76,38.85 KBC24.118
  L3 w0.102: v2(20.99,54.32) 20.99,53.79 20.56,53.36 20.56,52.91 21.21,52.25 21.21,51.11 23.74,48.57 23.74,45.3 29.44,39.6 35.52,33.52 43.82,33.52 44.21,33.91 77.6,33.91 81.62,29.89 82.95,29.89 87.25,25.6 94.4,25.6 96.68,23.31 96.68,22.98 97.39,22.27 98.87,22.27 99.51,22.9 105.27,22.9 105.99,22.19 107.31,22.19 108,21.51 115.14,21.51 117.81,18.84 130.83,18.84 131.42,19.42 131.94,19.42 134.46,19.42 136.57,21.53 136.57,23.17 136.07,23.67 136.07,24.95 137.26,26.13 147.47,26.13 148.09,26.75 151.08,26.75 152.47,28.14 154.17,28.14 155.61,29.58 155.61,34 155.33,34.28 155.33,36.51 v2(156.31,37.49)
  BOTTOM w0.102: R3401.1 18.97,54.36 19.08,54.48 20.83,54.48 v2(20.99,54.32)
USBCOMP: length 2.6
  TOP w0.254: R1603.1 81.83,81.06 81.45,81.06 v2(81.3,80.91) 81.4,80.91 81.74,80.56 v1(81.82,80.56)
  BOTTOM w0.305: v2(81.3,80.91) 81.12,81.09 CPU1.AB6
USBDET_CON#: length 6.2
  BOTTOM w0.102: Q2415.S 15.27,53.5 R2452.1 14.38,56.87 USB1.D1
USBDET_CON#_R: length 195.1
  TOP w0.102: R2496.1 158.36,38.05 158.36,38.23 157.96,38.63 KBC24.126 157.96,40.85 v2(158.16,41.05)
  L3 w0.102: v2(22.13,58.01) 20.99,56.86 20.99,54.94 20.48,54.43 20.48,53.57 20.35,53.44 20.35,52.82 20.99,52.18 20.99,51.02 23.53,48.48 23.53,45.21 29.22,39.51 35.43,33.31 43.91,33.31 44.3,33.69 77.43,33.69 81.57,29.56 82.84,29.56 87.2,25.19 94.51,25.19 96.48,23.23 96.48,22.9 97.3,22.07 98.96,22.07 99.59,22.7 105.19,22.7 105.9,21.99 107.23,21.99 107.92,21.3 115.06,21.3 117.73,18.64 130.92,18.64 131.5,19.22 131.86,19.22 134.54,19.22 136.77,21.45 136.77,23.35 136.28,23.84 136.28,24.86 137.34,25.93 147.66,25.93 148.26,26.53 153.07,26.53 156.14,29.6 156.14,33.99 155.57,34.56 155.57,35.91 158.16,38.5 v2(158.16,41.05)
  BOTTOM w0.102: v2(22.13,58.01) 22.13,57.88 21.88,57.63 v1(21.24,57.63) 19.59,57.63 19.08,57.12 15.28,57.12 14.95,56.79 14.95,55.78 15.34,55.4 Q2415.D
USBDISABLE: length 9.9
  TOP w0.152: U6901.31 85.21,105.26 84.94,105.52 84.94,105.95 84.61,106.28 v2(84.61,106.44)
  BOTTOM w0.152: R6904.2 90.14,103.47 v1(88.93,103.47) 87.59,103.47 v2(84.61,106.44)
V_SM_VREF_CNT: length 8.7
  BOTTOM w0.089: 92.43,45.23 92.17,45.23 91.91,45.49 91.91,45.67 91.72,45.86 91.23,45.86 91.16,45.84 CPU1.AY67
  BOTTOM w0.127: 94.01,42.39 94.01,43 93.12,43.88 93.12,44.54 92.43,45.23
  BOTTOM w0.508: v3(136.81,63.72) 137.19,63.72 137.4,63.93 R4208.2 C4201.1 ; 94.01,42.39 v2(94.01,41.32)
  vias: v1(94.9,42.89)
VCREF0: length 7
  TOP w0.102: R2424.1 164.73,53.09 164.73,53.8 R2448.1 C2409.1 163.32,53.85 v1(162.85,53.38) 162.55,53.09 162.55,52.15 161.27,50.87 KBC24.25
VD_IN1_C: length 6.6
  TOP w0.114: C2612.2 81.19,35.97 R2611.1 79.83,35.97 v1(79.08,36.73) 78.67,37.14 77.27,37.14 C2613.2 75.66,37.12 R2610.2
VOL_DOWN#: length 32.6
  TOP w0.102: v2(162.52,49.9) 162.65,50.03 R2499.1 R2460.1 162.34,49.19 162.27,49.27 KBC24.21
  L4 w0.102: v2(162.52,49.9) 162.31,49.9 161.22,48.81 161.22,47.24 159.59,45.61 158.83,45.61 158.81,45.59 150.78,45.59 150.33,45.13 148.87,45.13 146.94,47.06 146.94,47.29 142.82,51.4 v2(142.4,51.4)
  BOTTOM w0.102: v2(142.4,51.4) 142.95,51.4 143.3,51.75 IOBD1.15 ; v1(162.52,49.33) v2(162.52,49.9)
VOL_UP#: length 30.3
  TOP w0.102: R2456.1 162.06,41.54 161.14,42.47 KBC24.4 159.59,42.47 159.19,42.86 159.19,42.87 158.94,43.12 158.55,43.12 v2(158.13,42.69)
  L4 w0.102: v2(158.13,42.69) 158.13,42.99 157.68,43.43 157.68,43.46 157.23,43.91 157.23,44.17 156.67,44.74 152.65,44.74 152.43,44.52 151.06,44.52 150.86,44.72 148.71,44.72 146.39,47.04 146.39,47.26 145.81,47.84 142.37,47.84 142.05,48.16 142.05,50.29 v2(142.42,50.67)
  BOTTOM w0.102: R2498.1 141.82,49.66 v1(141.82,50.5) 142.25,50.5 v2(142.42,50.67) 142.87,50.67 143.29,50.25 IOBD1.12
VR_CAP: length 3.3
  TOP w0.203: KBC24.18 161.2,48.07 161.55,47.71
  TOP w0.254: 161.55,47.71 v1(162.07,47.19) 162.58,46.68 C2418.1
VR_EN: length 93
  TOP w0.102: v1(50.3,88.28) 50.42,88.16 v2(50.42,87.56)
  L4 w0.102: v2(39.58,43.91) 39.82,44.15 40.81,44.15 41.76,43.21 41.76,42.35 42.92,41.19 45.59,41.19 48.86,37.92 53.91,37.92 58.88,42.89 58.88,45.42 60.08,46.62 60.18,46.62 61.54,47.98 61.54,54.28 60.87,54.96 59.16,54.96 58.6,55.52 58.6,56.33 58.5,56.43 58.5,57.19 60.2,58.89 60.2,59.69 64.04,63.52 64.04,73.88 63.66,74.26 61.87,74.26 60.26,75.88 60.26,81.98 59.58,82.65 59.58,84.68 57.69,86.58 55.92,86.58 54.07,88.44 53.44,88.44 52.9,87.9 50.75,87.9 v2(50.42,87.56)
  BOTTOM w0.102: R4002.2 53.69,89.43 53.69,88.89 52.86,88.06 50.92,88.06 v2(50.42,87.56) ; PR4630.2 38.7,43.91 v2(39.58,43.91)
VR_RDY: length 5.3
  BOTTOM w0.102: PR4614.2 39.15,38.97 40.01,39.83 40.01,41.97 39.9,42.08 TP4603.1 39.9,43.06 PR4670.2
VR_SVID_ALERT#: length 41.2
  TOP w0.114: v2(65.69,45.69) 65.5,45.69 R727.2 64.19,44.38 63.12,44.38 61.97,45.54 60.2,45.54 59.88,45.21 v2(59.83,45.21)
  L3 w0.114: v2(59.83,45.21) 59.21,44.6 59.21,43.62 56.39,40.8 52.52,40.8 51.78,41.54 51.78,42.02 50.89,42.91 47.23,42.91 46.62,43.52 46.62,45.58 45.57,46.63 44.64,46.63 43.48,47.8 v2(40.88,47.8)
  BOTTOM w0.114: R728.1 65.24,43.52 66.19,43.52 66.69,44.02 66.69,45 v1(66.5,45.18) 66,45.69 v2(65.69,45.69) ; PR4666.1 40.56,47.8 v2(40.88,47.8) 41.35,47.33 41.35,46.87 40.42,45.94 PR4622.2
VR_SVID_CLK: length 37.5
  TOP w0.114: v2(59.82,43.66) 59.8,43.66 59.34,44.12 59.34,45.39 59.97,46.02 v1(61.14,46.02) 62.15,46.02 63.32,44.85 63.85,44.85 64.32,45.32 64.33,45.32 64.96,45.94 R723.2 64.75,46.59 64.75,47.01 R732.2
  L3 w0.114: v2(40.88,47.06) 41.14,47.33 43.29,47.33 44.45,46.16 45.37,46.16 46.15,45.39 46.15,43.32 47.04,42.44 47.43,42.44 50.69,42.44 51.31,41.82 51.31,41.35 52.32,40.33 56.88,40.33 59.82,43.27 v2(59.82,43.66)
  BOTTOM w0.114: PR4621.2 39.53,45.88 PR4665.1 40.27,46.45 v2(40.88,47.06)
VR_SVID_DATA: length 34.3
  TOP w0.114: R709.2 62.07,43.4 61.82,43.66 61.82,43.69 v2(61.12,44.39)
  L3 w0.114: v2(40.82,48.63) 41.19,48.27 43.68,48.27 44.84,47.1 45.86,47.1 47.09,45.87 47.09,43.71 47.43,43.38 51.08,43.38 52.25,42.21 52.25,41.74 52.71,41.27 56.2,41.27 58.71,43.78 58.71,44.76 59.63,45.68 60.02,45.68 61.12,44.58 v2(61.12,44.39)
  BOTTOM w0.114: PR4667.1 40.51,48.63 v2(40.82,48.63) 41.03,48.63 v1(41.59,48.07) 41.82,47.85 41.82,46.67 41.31,46.16 PR4623.1
VREFP: length 5.3
  TOP w0.102: HDA27.28 18.25,24.71 18.17,24.63 17.53,24.63 17.51,24.66 v2(17.49,24.66)
  BOTTOM w0.102: C2730.2 v1(16.22,25.27) 16.22,24.52 16.64,24.1 16.94,24.1 v2(17.49,24.66)
VTT_EN: length 5.4
  BOTTOM w0.102: PR5125.2 PC5120.1 133.74,83.34 PR5111.2 134.27,82.45 v1(134.19,82.37) 134.28,82.29 134.28,80.75 134.28,80.75 PU5102.7
WIFI_RF_EN: length 156.9
  TOP w0.102: EC6603.1 150.67,65.79 v2(150.09,66.38) 150.09,66.82 v1(150.39,67.12)
  L3 w0.102: v2(150.09,66.38) 149.63,66.84 149.27,66.84 148.68,66.25 148.68,61.1 v2(149.66,60.12)
  L4 w0.102: v2(68.76,86.07) 68.76,87.27 68.33,87.69 68.33,88.27 67.86,88.74 67.86,90.55 68.71,91.4 68.71,92.58 71.2,95.08 73.83,95.08 74.43,95.68 75.43,95.68 76.27,94.84 81.58,94.84 84.2,97.45 94.37,97.45 94.81,97.01 94.81,95.52 95.73,94.61 97.72,94.61 100.16,97.05 103.28,97.05 104.68,98.44 108.44,98.44 109.02,97.86 112,97.86 116.54,102.41 116.57,102.41 116.95,102.79 123.63,102.79 123.86,102.56 127.84,102.56 128.79,101.62 129.26,101.62 132.54,98.34 132.54,97.99 134.58,95.95 134.58,90.47 135.74,89.3 135.74,82.47 137.07,81.15 137.07,76.61 139.56,74.12 139.56,72 140.9,70.66 143.42,70.66 147.24,66.83 149.64,66.83 v2(150.09,66.38)
  BOTTOM w0.102: R1503.2 68.65,86.18 v2(68.76,86.07) 68.51,85.83 66.84,85.83 66.54,86.12 66.13,86.12 65.82,85.81 65.82,85.36 66.15,85.03 66.4,85.03 66.69,84.75 66.69,84.38 66.45,84.15 66.28,84.15 65.91,83.78 65.91,83.47 65.63,83.2 65.63,82.55 65.82,82.37 65.82,82.36 66.34,81.84 66.34,81.16 67.07,80.44 68.89,80.44 69.3,80.02 69.75,80.02 70.02,80.29 CPU1.B7 ; IOBD1.28 146.45,58.25 148.34,60.14 149.64,60.14 v2(149.66,60.12)
XCLK_BIASREF: length 2.3
  TOP w0.457: v1(71.91,60.7) 71.91,59.85 R1803.1
  TOP w0.508: R1803.1 72.5,59.78 v2(72.65,59.63)
  BOTTOM w0.305: CPU1.E42 72.31,59.97 v2(72.65,59.63)
XDP_BPM0: length 64.2
  TOP w0.114: v2(68.18,53.46) 68.08,53.36 v1(67.37,53.36) ; v2(103.35,30.27) 102.95,30.27 102.3,30.92 XDP1.21
  L4 w0.114: v2(103.35,30.27) 102.77,29.69 97.96,29.69 97.76,29.9 92.6,29.9 91.88,29.18 91.88,29.18 91.51,28.81 87.86,28.81 87.3,29.36 86.54,29.36 83.9,32.01 81.03,32.01 79.93,33.1 77.87,33.1 77.57,33.39 73.42,33.39 73.1,33.71 73.1,33.71 70.14,36.68 70.14,37.16 68.43,38.86 68.43,38.95 66.58,40.8 66.58,43.66 66.81,43.89 66.81,46.71 66.93,46.83 66.93,47.04 67.3,47.41 68.28,47.41 69.62,48.75 69.62,52.19 68.77,53.05 68.59,53.05 v2(68.18,53.46)
  BOTTOM w0.089: CPU1.C55 70.03,52.47 69.93,52.57 69.38,52.57 68.87,53.09 68.65,53.09 68.27,53.46 v2(68.18,53.46)
XDP_BPM1: length 62.2
  TOP w0.114: v2(71.1,53.49) 71.08,53.47 v1(71.08,52.81) ; XDP1.23 102.8,30.99 103.07,30.72 103.6,30.72 103.86,30.46 103.86,30.44 v2(103.98,30.32)
  L4 w0.114: v2(103.98,30.32) 103.59,30.71 103.02,30.71 102.32,30.01 101.82,30.01 100.91,30.91 92.71,30.91 91.24,29.44 88.12,29.44 87.56,30 87.07,30 84.43,32.64 81.29,32.64 80.2,33.73 78.13,33.73 77.83,34.03 73.68,34.03 70.77,36.94 70.77,37.42 69.07,39.12 69.07,39.21 67.21,41.07 67.21,41.88 67.9,42.57 67.9,43.33 67.45,43.78 67.45,45.67 71.1,49.32 v2(71.1,53.49)
  BOTTOM w0.114: CPU1.D55 71.21,53.38 v2(71.1,53.49)
XDP_BPM2: length 5.5
  BOTTOM w0.114: TP9901.1 66.58,55.34 68.14,55.34 69.48,54 70.08,54 70.24,53.84 CPU1.B54
XDP_BPM3: length 5.3
  BOTTOM w0.102: CPU1.C56 70.67,51.91 70.39,52.18 70.03,52.18 69.83,52.38 69.34,52.38 69.34,52.38 69.3,52.38 68.79,52.9 68.57,52.9 68.51,52.95 67.95,52.95 67.72,53.18
  BOTTOM w0.114: 67.72,53.18 67.6,53.31 TP9902.1
XDP_DBRESET#: length 115.6
  TOP w0.114: v2(84.61,95.34) 84.61,95.66 R1701.2 ; v2(108.26,42.49) 107.93,42.15 R9925.2 ; v2(68.38,82.95) 68.24,83.09 EC1706.1
  L4 w0.114: v2(68.38,82.95) 68.38,84.3 69.2,85.11 69.2,87.27 68.64,87.82 68.64,88.4 68.17,88.87 68.17,90.42 69.02,91.27 69.02,92.45 71.33,94.77 73.11,94.77 73.32,94.56 75.32,94.56 76.09,93.78 80.97,93.78 82.53,95.34 v2(84.61,95.34) 84.61,95.38 86.37,97.14 92.53,97.14 93.89,95.78 93.89,95.76 93.93,95.72 93.93,95.31 94.94,94.3 99.12,94.3 100.28,95.45 103.39,95.45 104.55,96.61 105.1,96.61 105.55,96.16 v2(105.55,96.1)
  BOTTOM w0.114: CPU1.B5 70.24,81.99 69.71,82.51 68.82,82.51 v2(68.38,82.95) ; v2(108.26,42.49) v1(108.26,61.08) 108.26,62.05 109.92,63.7 109.92,83.17 111.44,84.69 111.44,87.25 110.65,88.04 109.79,88.04 108.34,89.48 108.34,93.26 105.79,95.81 105.79,95.85 v2(105.55,96.1)
XDP_DBRESET_XDP#: length 4.7
  TOP w0.114: v1(107.04,41.4) 107.53,40.92 R9925.1 C9905.1 108.8,40.86 XDP1.48
XDP_PRDY#: length 58.4
  TOP w0.114: XDP1.5 98.3,30.62 v2(98.15,30.47)
  L4 w0.114: v2(68.82,53.49) 69.94,52.36 69.94,48.61 67.13,45.81 67.13,43.76 66.89,43.52 66.89,41.2 66.89,40.94 68.75,39.08 68.75,38.99 70.45,37.29 70.45,36.81 73.55,33.71 77.7,33.71 78,33.41 78.13,33.41 80.07,33.41 81.16,32.32 84.26,32.32 86.91,29.68 87.43,29.68 87.99,29.12 91.37,29.12 92.66,30.41 98.09,30.41 v2(98.15,30.47)
  BOTTOM w0.089: v2(68.82,53.49) 68.94,53.36 68.99,53.36 69.28,53.07 69.28,52.92 69.43,52.77 70.66,52.77 70.91,52.52 70.91,52.36 71.37,51.91 CPU1.D56
  BOTTOM w0.114: v2(68.82,53.49) 68.38,53.92 67.35,53.92 v1(67.29,53.85)
XDP_PREQ#: length 43.2
  TOP w0.114: v2(97.7,33.88) 97.8,33.77 XDP1.3
  L4 w0.114: v2(97.7,33.88) 93.21,33.88 91.55,35.54 87.97,35.54 87.39,34.95 82.25,34.95 80.92,36.28 79.75,36.28 79.11,36.92 75.3,36.92 73.08,39.14 72.22,39.14 71.86,39.5 71.86,40.11 71.76,40.2 71.76,43.95 71.26,44.45 71.26,47.35 71.23,47.38 71.23,48.27 72.57,49.61 v2(72.63,49.61)
  BOTTOM w0.114: v2(72.63,49.61) 71.72,49.61 CPU1.D61 ; v1(97.31,33.45) 97.67,33.8 97.67,33.85 v2(97.7,33.88)
XDP_PRSNT_PIN1: length 3.6
  TOP w0.114: XDP1.1 97.3,29.89 R9902.2 98.41,29.56 98.41,29.56 v1(98.53,29.56)
XDP_SMBCLK: length 5.3
  TOP w0.114: v1(113.42,28.82) 112.72,29.52 R9912.2 111.75,30.24 110.9,30.24 110.3,30.84 XDP1.53
XDP_SMBDAT: length 3.9
  TOP w0.114: v1(111.54,29.38) 111.3,29.62 R9911.2 110.62,30.03 109.96,30.7 109.96,30.7 109.89,30.77 109.89,30.78 109.8,30.87 XDP1.51
XDP_SPI0_IO2: length 95.9
  TOP w0.114: v2(95.98,87.22) 95.54,86.77 R1827.1 ; XDP1.60 112.61,38.14 115.6,35.15 115.6,32.67 R9931.1 R9929.2 117,32.52 116.69,32.83 v1(116.69,35.22) 116.75,35.27 116.75,39.85 114.08,42.51 v2(113.82,42.51)
  L4 w0.114: v2(110.14,92.93) 110.03,92.81 109.03,92.81 106.29,90.07 102.77,90.07 100.98,88.28 98.77,88.28 96.9,90.16 96.33,90.16 95.74,89.56 95.74,87.57 95.98,87.33 v2(95.98,87.22)
  BOTTOM w0.114: v2(110.14,92.93) 110.27,92.8 110.27,92.09 109.97,91.8 109.97,89.7 109.96,89.68 109.96,89.32 110.21,89.06 111.08,89.06 112.47,87.68 112.47,84.26 111.03,82.82 111.03,51.53 110.65,51.15 110.65,49.26 113.82,46.08 v2(113.82,42.51)
XDP_TCK_JTAGX: length 89.4
  TOP w0.114: v1(117.28,28.77) 117.04,29.01 R9915.2 115.82,29.01 v2(115.65,29.18)
  L4 w0.114: v2(65.95,49.47) 65.72,49.47 65.37,49.82 65.37,50.63 65.88,51.14 67.87,51.14 68.14,51.41 68.14,51.75 67.85,52.04 67.61,52.04 66.71,52.93 65.53,52.93 63.98,51.38 63.98,47.1 62.69,45.81 62.69,44.62 64.4,42.91 64.4,40.44 64.4,39.81 64.79,39.42 64.79,39.41 66.08,38.12 66.08,37.57 72.45,31.19 76.74,31.19 76.98,30.95 79.05,30.95 80.14,29.86 80.69,29.86 81.24,29.31 83.34,29.31 86.42,26.23 106.44,26.23 106.49,26.29 111.3,26.29 113.7,28.68 115.16,28.68 v2(115.65,29.18)
  BOTTOM w0.114: CPU1.A59 69.41,50.74 66.77,50.74 66.47,50.44 66.47,50 v2(65.95,49.47) 65.79,49.32 65.79,49.31 65.49,49 65.49,48.62 65.12,48.25 R417.1
XDP_TCLK: length 82.7
  TOP w0.114: v2(67.49,48.58) 67.28,48.37 R406.1 ; XDP1.57 111.3,33.46 111.03,33.73 v2(111.03,33.88) 112.5,33.88 114.45,31.93 114.45,30.6 114.98,30.07 116.12,30.07 116.29,29.9 R9915.1 117.11,29.9 v1(117.28,30.07)
  L4 w0.114: v2(67.49,48.58) 66.97,48.05 66.92,48.05 66.06,47.19 66.06,46.09 66.13,46.01 66.13,45.09 65.84,44.8 65.84,44.44 66.12,44.16 66.12,40.54 66.21,40.45 66.3,40.36 66.64,40.02 67.77,38.89 67.77,38.27 73.1,32.94 77.38,32.94 77.68,32.64 79.75,32.64 80.84,31.55 83.54,31.55 86.33,28.76 86.33,28.74 86.59,28.49 86.61,28.49 87.11,27.98 91.67,27.98 93.13,29.44 97.57,29.44 97.88,29.13 105.14,29.13 106.37,30.36 106.37,30.52 105.73,31.16 105.73,31.34 105.95,31.57 106.13,31.57 106.77,30.92 106.93,30.92 107.18,31.17 107.18,31.33 106.53,31.97 106.53,32.15 106.76,32.37 106.94,32.37 107.58,31.73 107.74,31.73 107.99,31.98 107.99,32.14 107.33,32.79 107.33,32.97 107.55,33.2 107.73,33.2 108.39,32.54 108.55,32.54 109.13,33.11 110.27,33.11 v2(111.03,33.88)
  BOTTOM w0.089: 67.94,49.03 67.95,49.03 68.19,49.03 68.32,49.17 69.69,49.17 69.82,49.23 70.04,49.23 CPU1.B61
  BOTTOM w0.114: 67.94,49.03 v2(67.49,48.58)
XDP_TCLK1: length 5.9
  TOP w0.114: XDP1.55 110.8,30.99 111.09,30.7 112.33,30.7 113.11,29.91 v1(114.01,29.91) 114.31,29.91 114.65,29.57 R9914.1
XDP_TDI: length 89.9
  TOP w0.114: v1(108.34,43.17) 108.5,43.34 R9916.1 110.29,43.34 111.11,42.53 111.11,40.68 110.8,40.38 XDP1.56 110.8,36.97 111.03,36.74 111.03,36.29 v2(111.54,35.78)
  L4 w0.114: v2(111.54,35.78) 111.79,35.53 111.79,33.54 110.22,31.97 109.08,31.97 105.43,28.32 94.03,28.32 92.89,27.18 86.81,27.18 86.28,27.71 86.27,27.71 85.56,28.42 85.56,28.44 83.22,30.77 80.51,30.77 79.42,31.86 77.36,31.86 77.12,32.11 72.83,32.11 72.2,32.74 66.99,37.95 66.99,38.21 66.99,38.57 65.34,40.22 65.34,40.86 65.32,40.88 65.32,43.28 64.92,43.69 64.92,50.46 65.81,51.36 65.85,51.36 v2(66.38,51.89)
  BOTTOM w0.089: CPU1.D60 71.45,49.99 71.87,50.42 71.87,50.69 71.68,50.89 71.38,50.89 70.7,51.57 69.5,51.57
  BOTTOM w0.114: 69.5,51.57 69.49,51.57 69.3,51.76 69,51.76 68.55,52.21 67.28,52.21 67.19,52.3 66.79,52.3 v2(66.38,51.89) 66.38,51.42 65.07,50.11 R422.1
XDP_TDO_CPU: length 72.2
  TOP w0.114: R423.1 65.61,48.12 66.38,48.12 66.83,48.57 v2(66.83,48.58) ; R9919.1 109.55,42.28 v2(109.73,42.46)
  L4 w0.114: v2(66.83,48.58) 66.83,48.97 66.49,49.32 66.49,49.57 66.09,49.97 65.86,49.97 65.62,50.22 65.62,50.59 65.85,50.83 66.56,50.83 66.63,50.9 67.19,50.9 67.32,50.77 68.1,50.77 68.49,51.15 68.49,51.78 67.93,52.34 67.71,52.34 67.06,52.99 67.06,53.93 69.02,55.89 69.21,55.89 69.63,56.31 75.4,56.31 75.42,56.29 76.21,56.29 82.44,50.06 83.35,50.06 85.02,48.38 85.02,45.1 86.42,43.71 90.68,43.71 91.79,42.6 91.79,41.44 92.37,40.86 97.16,40.86 99.09,38.92 108.7,38.92 110.01,40.24 110.01,42.18 v2(109.73,42.46)
  BOTTOM w0.114: v2(66.83,48.58) 66.88,48.58 67.54,49.24 68.12,49.24 68.24,49.36 69.52,49.36 CPU1.A61 ; v1(109.73,43.1) v2(109.73,42.46)
XDP_TMS: length 83.7
  TOP w0.114: v2(111.56,36.44) 111.56,36.71 111.3,36.97 XDP1.58 111.3,39.58 111.53,39.81 114.75,39.81 116.05,38.51 R9917.1 v1(116.24,37.61)
  L4 w0.114: v2(66.2,48.56) 65.25,47.61 65.25,43.88 65.66,43.47 65.66,40.35 65.94,40.07 65.98,40.03 66.45,39.56 67.31,38.7 67.31,38.08 72.52,32.87 72.97,32.42 77.25,32.42 77.49,32.18 79.56,32.18 80.65,31.09 83.35,31.09 85.88,28.57 85.88,28.55 86.4,28.03 86.42,28.03 86.92,27.52 91.99,27.52 93.45,28.98 97.38,28.98 97.69,28.67 105.33,28.67 109.14,32.48 110.28,32.48 111.47,33.67 111.47,35.22 111.1,35.59 111.1,35.98 v2(111.56,36.44)
  BOTTOM w0.089: CPU1.C60 70.29,49.99 70.24,49.94 69.12,49.94 68.99,50.06
  BOTTOM w0.114: R421.1 65.52,46.93 65.52,47.36 66.17,48.02 66.17,48.53 v2(66.2,48.56) 66.22,48.58 66.25,48.58 66.82,49.16 67.17,49.16 67.44,49.43 67.44,49.75 67.76,50.06 68.99,50.06 68.99,50.06
XDP_TRST#: length 73.7
  TOP w0.114: R402.1 110.3,40.86 XDP1.54 110.3,36.59 v2(110.43,36.47) ; v2(66.91,50.23) 67.32,50.23 v1(67.46,50.09) 67.9,49.65 v2(67.93,49.65)
  L4 w0.114: v2(67.93,49.65) 68.27,50 68.38,50 69.3,50.92 69.3,52.06 68.63,52.73 68.5,52.73 68.21,53.02 68,53.02 67.74,53.28 67.74,53.64 69.03,54.93 69.21,54.93 69.9,55.61 74.72,55.61 74.74,55.63 75.11,55.63 75.14,55.6 75.92,55.6 81.92,49.6 81.92,47.29 81.92,45.63 82.45,45.1 82.84,45.1 84.97,42.98 90.44,42.98 91.09,42.33 91.09,39.97 91.66,39.41 92.29,39.41 92.98,40.1 96.89,40.1 98.76,38.24 108.66,38.24 v2(110.43,36.47)
  BOTTOM w0.089: CPU1.B59 70.2,50.55 69.94,50.29 69.39,50.29 69.2,50.49 ; v2(67.93,49.65) 67.96,49.69 70.39,49.69 70.43,49.64 70.67,49.64 CPU1.C61
  BOTTOM w0.114: v2(66.91,50.23) 67.17,50.49 69.2,50.49
XTAL1: length 19.7
  TOP w0.114: KBC24.123 156.76,40.36 156.85,40.45 156.85,41.25 156.34,41.76 156.34,42 155.93,42.4 154.26,42.4 153.28,41.42 152.33,41.42 151.79,40.89 v2(151.52,40.89)
  BOTTOM w0.114: v2(151.52,40.89) 151.45,40.89 149.96,39.4 v1(149.96,38.83) 149.96,37.56 150.27,37.24 150.27,36.61 150.93,35.95 150.93,35.25 151.4,34.78 151.4,33.86 151.3,33.75 150.92,33.75 C2425.2 150.46,32.57 X2401.1
XTAL2: length 18.6
  TOP w0.114: v2(153.07,42.62) 153.42,42.96 156.18,42.96 157.09,42.05 157.3,42.05 157.55,41.79 157.55,41.44 157.72,41.27 157.72,40.68 157.56,40.51 KBC24.125
  BOTTOM w0.114: R2458.2 150.63,34.76 150.17,35.23 R2493.2 150.17,35.93 149.71,36.38 149.71,37.01 149.4,37.32 149.4,39.78 150.64,41.02 v1(150.64,41.02) 150.64,41.03 150.98,41.37 150.98,41.9 151.39,42.31 151.65,42.31 152.1,42.77 152.56,42.77 152.71,42.62 v2(153.07,42.62)
XTAL24_IN: length 15.1
  BOTTOM w0.114: CPU1.E37 71.56,62.12 71.41,62.12 71.38,62.08 71.09,62.08 71.05,62.12 70.76,62.12 70.73,62.08 70.44,62.08 70.09,62.43 67.92,62.43 65.36,64.99 62.71,64.99 v1(62.64,65.06) R1802.1 C1801.2 59.57,65.06 X1801.1
XTAL24_OUT: length 13.5
  BOTTOM w0.114: R1810.1 R1802.2 63.09,65.94 63.48,65.55 v1(64.88,65.55) 65.64,65.55 68.52,62.67 70.39,62.67 70.4,62.68 70.73,62.68 70.76,62.65 71.01,62.65 71.24,62.87 71.24,63.07 71.45,63.28 71.8,63.28 CPU1.E35
XTAL24_OUT_R: length 6.5
  BOTTOM w0.114: X1801.3 57.41,67.91 60.55,67.91 C1802.2 R1810.2 62.12,67.72 v1(62.54,67.3)
XTAL_KBC_2: length 6.4
  BOTTOM w0.114: v1(145.18,31.53) 146.68,31.53 X2401.2 146.9,31.75 146.9,32.11 147.53,32.73 149.02,32.73 C2424.2 149.74,33.46 R2458.1
ZVM#: length 1.4
  TOP w0.102: TP616.1 87.47,52.1 v2(87.47,52.4)
  BOTTOM w0.102: CPU1.AR56 87.8,52.07 v2(87.47,52.4)
N18046859: length 4
  TOP w0.102: 25.14,24.31 HDA27.4 ; 25.14,24.31 25.14,24.63 25.05,24.71 HDA27.5 ; 25.14,24.31 25.89,24.31 R2701.2 26.78,23.76 v1(26.78,23.56)
N78881610: length 7
  BOTTOM w0.254: PU4301.4 39.35,29.12 39.41,29.17 PC4302.2 PR4308.2 41.37,28 PR4309.1 41.34,26.9 v1(41.23,26.78)

## Copper pours and planes (outline as drawn)
5V_HDMI_R_S5 on TOP: 19.21,90.65 18.19,91.66 16.67,91.66 16.54,91.79 16.54,92.8 16.8,93.06 21.24,93.06 21.37,92.93 21.37,92.04 21.62,91.79 21.62,90.77 21.5,90.65 ; 1 cut-out
5V_HDMI_S5 on TOP: 10.83,87.98 10.57,88.23 10.57,88.99 12.48,90.9 14.31,90.9 14.61,91.2 18.08,91.2 18.32,90.96 18.32,90.01 18.17,89.86 15.07,89.86 13.85,88.64 13.85,88.46 13.37,87.98 ; 2 cut-outs
5V_HDMI_S5 on L6: 9.18,86.71 9.05,86.84 9.05,88.99 9.48,89.43 11.74,89.43 12,89.17 12,88.13 10.57,86.71
5V_S0 on TOP: 23.53,28.29 23.53,28.54 23.78,28.8 24.16,28.8 24.54,29.18 24.54,29.69 24.29,29.94 22.89,29.94 22.26,29.3 22,29.3 21.75,29.56 21.75,29.81 22.26,30.32 22.26,31.34 22.38,31.46 22.89,31.46 23.15,31.72 25.69,31.72 26.19,32.23 27.21,32.23 27.34,32.35 27.34,32.99 26.83,33.5 26.83,34.89 26.96,35.02 27.59,35.02 27.72,34.89 27.72,34.13 28.23,33.62 28.23,32.35 28.86,31.72 28.86,31.34 27.85,30.32 26.32,30.32 25.43,29.43 25.43,28.92 25.31,28.8 25.05,28.8 24.54,28.29 ; 6 cut-outs
5V_S0 on TOP: 76.36,28.62 76.23,28.75 76.23,30.75 76.28,30.8 77.53,30.8 77.68,30.65 77.68,29.53 76.77,28.62
5V_S0 on TOP: 131.55,47.92 133.38,49.75 133.38,53.94 136.94,57.5 136.94,62.83 137.57,63.47 137.57,64.23 137.19,64.61 137.19,67.53 136.81,67.91 136.81,68.29 137.07,68.55 137.7,68.55 138.21,68.04 138.21,65.12 138.72,64.61 138.72,62.83 137.95,62.07 137.95,56.86 134.53,53.43 134.53,49.24 133.76,48.48 133.76,43.27 133.62,43.14 133.62,39.26 134.54,38.35 135.72,38.35 136.07,37.99 136.07,36.77 136.42,36.43 136.42,36.15 136.63,35.93 136.63,34.13 136.62,34.12 136.62,33.89 135.95,33.22 132.14,33.22 131.55,33.8 ; 2 cut-outs
5V_S0 on TOP: 24.04,91.66 23.65,92.04 22,92.04 21.88,92.17 21.88,92.93 22,93.06 24.04,93.06 25.05,94.07 25.05,96.23 26.7,97.88 26.7,100.04 26.83,100.17 28.35,100.17 28.61,99.92 28.61,96.74 28.23,96.36 26.83,96.36 26.45,95.98 26.45,93.95 26.7,93.69 29.37,93.69 29.75,93.31 29.75,91.92 29.62,91.79 28.48,91.79 28.35,91.66 ; 2 cut-outs
5V_S0 on BOTTOM: 25.43,90.9 25.31,91.03 25.31,93.57 25.43,93.69 27.72,93.69 27.85,93.57 27.85,93.06 26.58,91.79 26.58,90.9
5V_S0 on BOTTOM: 25.81,15.08 25.69,15.21 25.69,16.22 27.21,17.75 27.21,18.26 27.34,18.38 28.61,18.38 28.86,18.13 28.86,15.21 28.73,15.08 ; 3 cut-outs
5V_S0 on BOTTOM: 131.43,26.79 131.43,27.96 131.32,28.06 131.32,28.8 130.12,30 130.12,32.69 130.28,32.84 130.73,32.84 130.75,32.86 130.84,32.86 133.26,35.27 134.14,35.27 134.4,35.02 134.4,34 132.75,32.35 132.75,31.97 132.95,31.77 133.38,31.77 133.52,31.64 133.52,30.85 133.51,30.84 133.51,28.29 133.2,27.98 133.2,26.79 ; 4 cut-outs
5V_S0 on L2VCC: 129.96,29.44 129,30.4 129,33.22 129.75,36.58 129.76,36.59 129.76,36.65 129.78,36.71 129.76,36.73 129.74,44.69 130.06,45.01 133.3,45.01 133.83,44.69 133.83,37.86 135.22,36.47 135.22,32.16 133.52,29.98 131.78,29.44
5V_S0 on L3: outline of 93 points within 13.88,16.48 79.03,95.85
5V_S0 on L4: 26.58,37.31 27.85,36.04 27.85,34.89 27.34,34.38 27.34,33.37 27.97,32.73 29.12,32.73 30.13,33.75 30.13,37.31 23.78,43.66 23.65,43.66 22.51,44.8 22.51,49.37 20.73,51.15 20.73,69.31 19.34,70.71 19.34,82.9 18.57,83.66 18.57,86.71 18.96,87.09 20.35,87.09 23.78,90.52 25.56,90.52 27.46,92.42 27.97,92.42 28.1,92.55 28.1,94.58 27.46,95.22 23.15,95.22 20.35,92.42 18.7,92.42 13.62,87.34 13.62,80.38 14.38,79.62 14.38,73.25 15.02,72.61 15.02,71.72 16.16,70.58 16.16,65.37 17.3,64.23 17.3,59.78 17.94,59.15 17.94,58.13 17.05,57.24 17.05,46.83 18.57,45.31 18.57,42 20.23,40.35 21.88,40.35 24.92,37.31
5V_S0 on L4: 131.91,45.13 133.66,45.13 134.19,44.6 134.19,38.32 133.71,37.84 131.76,37.84 131.48,38.12 131.48,40.76 132.04,41.32 132.04,41.85 131.55,42.34 131.55,44.77
5V_S0 on L6: 78.64,27.9 79.71,26.83 79.79,26.83 80.23,26.38 83.09,26.38 86.9,22.57 87.53,22.57 88.16,21.94 95.16,21.94 96.81,23.59 102.39,23.59 103.28,22.7 105.82,22.7 106.08,22.44 108.1,22.44 109.05,21.49 124.43,21.49 126.27,23.34 126.78,23.34 128.81,25.37 128.81,30.45 129.06,30.7 132.11,30.7 132.94,29.88 132.94,19.99 131.53,18.57 108.19,18.57 108.18,18.58 105.12,18.58 103.79,19.91 97.31,19.91 96.93,20.29 85.63,20.29 83.22,22.7 78.9,22.7 75.98,25.62 75.98,31.08 76.49,31.59 78.14,31.59 78.65,31.08 78.65,29.18 78.64,29.17
5V_S5 on TOP: 25.91,80.1 25.31,80.71 25.31,85.06 22.13,88.23 22.13,90.01 21.88,90.26 21.88,91.53 22,91.66 23.02,91.66 24.04,90.65 30.51,90.65 30.51,87.72 30.07,87.28 30.07,86.14 28.99,85.06 28.99,80.92 28.18,80.1 ; 2 cut-outs
5V_S5 on TOP: 25.31,48.61 24.42,49.5 24.42,51.66 25.05,52.29 26.07,52.29 26.45,51.91 26.45,48.86 26.19,48.61 ; 3 cut-outs
5V_S5 on TOP: 63.48,87.85 63.38,87.95 63.38,89.38 63.03,89.72 62.58,89.72 62.51,89.8 62.51,90.53 62.54,90.56 63.5,90.56 63.55,90.51 63.55,90.02 63.61,89.96 63.88,89.96 64.17,89.68 64.17,88 64.01,87.85
5V_S5 on BOTTOM: 42.46,64.76 42.39,64.83 42.39,65.12 42,65.5 41.82,65.5 41.69,65.63 41.69,66.26 41.82,66.39 43.09,66.39 43.34,66.64 43.85,66.64 43.85,65.12 43.78,65.05 43.21,65.05 42.92,64.76 ; 1 cut-out
5V_S5 on BOTTOM: 24.16,47.97 23.91,48.23 23.91,50.13 24.04,50.26 25.56,50.26 25.69,50.39 25.69,50.89 25.56,51.02 24.29,51.02 24.16,51.15 24.16,53.18 25.43,53.18 26.7,51.91 26.7,48.99 25.69,47.97
5V_S5 on BOTTOM: 26.12,79.98 25.25,80.84 25.25,83.97 25.43,84.14 25.43,86.07 23.86,87.65 23.86,89.5 24.54,90.19 24.54,90.44 24.62,90.52 26.19,90.52 26.38,90.33 26.38,88.42 26.96,87.85 28.1,87.85 29.5,86.45 29.5,80.56 28.91,79.98 ; 1 cut-out
5V_S5 on BOTTOM: 141.26,66.77 140.75,67.28 140.75,68.55 141.64,69.44 144.3,69.44 144.43,69.31 144.43,67.15 143.16,67.15 142.78,66.77
5V_S5 on L2VCC: 25.88,73.42 27.53,71.77 27.53,57.04 28.54,56.02 28.54,49.2 28.02,48.67 25,48.67 24.48,49.2 24.48,53.61 24.73,53.86 24.73,54.91 22.96,56.69 22.96,65.07 21.94,66.09 21.94,70.02 21.18,70.79 21.18,74.09 19.65,75.61 19.65,83.46 21.81,85.61 21.81,87.65 23.99,89.82 27.51,89.82 28.67,88.66 28.67,81.2 25.88,78.41
5V_S5 on L4: 38.51,29.18 37.24,30.45 37.24,31.34 36.74,31.84 35.59,31.84 33.75,33.69 33.75,39.66 31.27,42.13 27.21,42.13 24.42,44.93 24.42,54.83 22.89,56.36 22.89,58.64 22.77,58.77 22.77,65.06 21.65,66.17 21.65,69.98 21.11,70.52 21.11,72.87 20.61,73.37 20.61,74.26 20.1,74.77 20.1,83.91 21.75,85.57 21.75,87.47 24.04,89.76 27.59,89.76 28.73,88.61 28.73,80.84 27.74,79.85 26.45,79.85 25.94,79.34 25.94,73.5 27.59,71.85 27.59,63.72 28.61,62.71 28.61,61.31 28.1,60.8 28.1,56.86 28.61,56.36 28.61,49.37 29.5,48.48 29.5,46.58 30.77,45.31 31.53,45.31 32.29,44.54 33.05,44.54 36.99,40.61 36.99,38.32 36.61,37.94 36.61,36.29 39.66,33.24 63.66,33.24 64.04,32.86 64.04,30.07 63.66,29.69 53.88,29.69 53.37,29.18 ; 2 cut-outs
5V_S5 on L5GND: 105.27,18.7 103.87,20.1 97.27,20.1 96.88,20.48 85.58,20.48 83.3,22.76 78.72,22.76 76.56,24.92 71.87,24.92 68.31,28.48 63.86,28.48 62.07,30.27 62.07,32.15 62.98,33.05 69.04,33.05 71.98,30.12 71.98,29.35 73.11,28.23 79.58,28.23 81.11,26.7 83.39,26.7 86.69,23.4 102.32,23.4 103.08,22.64 105.49,22.64 106.25,21.88 114.54,21.88 115.3,22.64 126.35,22.64 133.32,29.61 133.32,34.81 133.71,35.21 137.37,35.21 137.89,34.69 137.89,23.29 133.3,18.7
5V_S5 on L6: 133.1,33.91 142.21,43.02 143.29,43.02 143.67,43.4 143.67,44.54 144.4,45.28 144.4,47.82 148.5,51.91 148.5,54.45 147.73,55.21 147.73,56.23 144.56,59.4 144.56,62.47 143.16,63.88 143.16,66.01 143.03,66.13 141.64,66.13 140.88,66.9 140.88,68.29 141.38,68.8 143.8,68.8 144.94,67.66 144.94,66.9 145.45,66.39 145.7,66.39 148.37,63.72 148.37,59.4 148.88,58.9 150.65,58.9 151.8,57.75 151.8,54.45 151.29,53.94 151.29,48.74 149.77,47.21 149.77,40.73 146.34,37.31 145.32,37.31 143.16,35.15 142.53,35.15 141.51,34.13 141.51,30.07 141.76,29.81 144.86,29.81 145.04,29.64 145.04,28.9 144.43,28.29 139.35,28.29 137.07,30.57 133.89,30.57 133.1,31.37
5V_S5 on L6: 27.08,58.64 27.08,49.62 26.19,48.74 25.18,48.74 24.42,49.5 24.42,58.64 24.67,58.9 26.83,58.9
+5V_KB_BL on BOTTOM: 24.11,9.49 24.04,9.57 24.04,11.4 24.8,12.16 24.8,14.57 25.05,14.83 28.61,14.83 28.86,14.57 28.86,13.05 28.48,12.67 26.96,12.67 26.58,12.29 26.58,10.25 26.45,10.13 25.53,10.13 24.9,9.49 ; 2 cut-outs
+V1.00A_SIP on TOP: 76.23,69.56 75.85,69.94 75.85,71.09 76.11,71.34 76.74,71.34 76.99,71.09 77.25,71.09 77.5,71.34 77.88,71.34 78.01,71.21 78.01,70.83 78.14,70.71 79.79,70.71 80.04,70.96 80.04,73.37 80.3,73.63 81.57,73.63 81.69,73.5 81.69,73.12 81.31,72.74 80.93,72.74 80.8,72.61 80.8,71.09 80.55,70.83 80.55,70.58 80.93,70.2 80.93,69.82 80.8,69.69 80.17,69.69 80.04,69.56 ; 1 cut-out
+V1.00A_SIP on TOP: 68.87,75.66 68.49,76.04 68.49,77.18 68.87,77.56 68.87,77.82 68.61,78.07 68.23,78.07 68.1,78.2 68.1,78.71 68.23,78.83 68.61,78.83 68.74,78.96 68.74,83.15 67.98,83.91 67.49,83.91 65.49,85.92 64.42,85.92 64.27,86.07 64.27,87.83 64.55,88.11 66.92,88.11 68.36,86.67 68.36,85.82 68.49,85.69 69.25,85.69 70.01,84.93 70.01,75.91 69.76,75.66 ; 4 cut-outs
+V1.00A_SIP on TOP: 77.88,83.66 77.25,84.3 77.25,84.93 77.63,85.31 78.01,85.31 78.26,85.06 78.65,85.06 79.03,84.68 79.03,83.79 78.9,83.66
+V1.00A_SIP on L3: 71.91,74.26 73.82,74.26 74.2,73.88 74.2,72.87 74.07,72.74 71.79,72.74 70.77,73.75 68.99,73.75 68.87,73.88 68.87,74.26 68.99,74.39 70.01,74.39 70.26,74.64 70.26,75.02 70.14,75.15 69.5,75.15 68.99,75.66 68.74,75.66 68.61,75.79 68.61,76.17 68.87,76.42 69.76,76.42
+V1.00A_SIP on L4: 77.12,89.38 77.38,89.12 77.38,88.36 77.5,88.23 78.26,88.23 78.9,87.6 78.9,84.42 79.53,83.79 81.06,83.79 82.61,82.24 82.61,74.62 84.87,72.36 84.87,71.98 84.74,71.85 83.98,71.85 83.34,72.48 81.44,72.48 80.8,71.85 80.3,71.85 80.17,71.98 80.17,73.88 79.53,74.52 79.53,78.2 79.08,78.66 79.08,79.93 79.53,80.38 79.53,81.5 77.5,83.53 77.5,86.96 76.36,88.11 76.36,89.12 76.61,89.38
+V1.00A_SIP on L6: 76.99,89.5 76.61,89.5 76.11,88.99 75.34,88.99 74.84,88.49 70.97,88.49 70.29,87.8 67.37,87.8 66.91,87.34 66.91,85.11 67.98,84.04 68.87,84.04 69.5,83.41 72.04,83.41 72.68,84.04 75.34,84.04 75.6,84.3 75.6,86.45 75.85,86.71 76.36,86.71 76.61,86.45 76.61,84.55 76.99,84.17 78.01,84.17 78.26,84.42 78.26,88.23
+V1.00U_CPU on BOTTOM: 63.96,81.04 63.74,81.27 63.74,83.33 63.84,83.43 64.47,83.43 65.67,82.24 65.67,81.2 65.51,81.04 ; 1 cut-out
+V1.8A on TOP: 82.96,91.28 82.84,91.41 82.84,93.44 81.57,94.71 81.57,98.65 78.39,101.82 74.45,101.82 74.2,102.08 73.06,102.08 72.8,102.33 72.8,102.71 73.06,102.96 74.45,102.96 74.84,102.58 78.77,102.58 82.33,99.03 82.33,95.34 83.73,93.95 83.73,91.41 83.6,91.28
+V1.8A on BOTTOM: 34.58,8.35 33.69,9.24 31.78,9.24 31.66,9.37 31.66,11.4 31.02,12.03 31.02,13.05 31.27,13.3 32.42,13.3 33.69,12.03 35.47,12.03 35.59,11.91 35.59,8.48 35.47,8.35 ; 1 cut-out
+V1.8A on BOTTOM: 20.99,32.99 20.86,33.11 20.86,33.62 20.61,33.88 20.35,33.88 20.23,34 20.23,34.38 20.35,34.51 22,34.51 22.13,34.64 22.13,34.89 22.26,35.02 23.15,35.02 23.27,34.89 23.27,33.62 23.02,33.37 22,33.37 21.62,32.99 ; 1 cut-out
+V1.8A on L6: 33.31,11.4 32.42,10.51 29.62,10.51 27.59,12.54 26.19,12.54 24.04,14.7 24.04,26.51 22,28.54 22,30.32 20.29,32.04 20.29,33.31 20.99,34 22.38,34 24.54,31.84 25.05,31.84 26.19,30.7 26.19,29.18 26.58,28.8 26.58,23.97 26.19,23.59 26.19,20.54 27.72,19.02 27.72,15.97 30.39,13.3 32.54,13.3 33.31,12.54
+V1.8A_SIP on TOP: 79.66,86.84 79.41,87.09 79.41,87.34 79.66,87.6 81.82,87.6 82.07,87.85 82.07,89.63 84.23,91.79 84.23,92.17 84.36,92.3 85.38,92.3 86.3,91.37 86.3,91.14 86.52,90.93 86.52,90.39 86.39,90.26 85.63,90.26 85.5,90.39 85.5,91.03 85.38,91.15 84.74,91.15 82.84,89.25 82.84,87.22 82.46,86.84
+V1.8A_SIP on L3: 86.27,82.64 84.36,80.74 84.36,78.58 84.11,78.33 84.11,75.66 82.46,74.01 82.46,71.98 82.33,71.85 81.95,71.85 81.69,72.1 81.69,77.18 82.2,77.69 82.46,77.69 82.71,77.95 82.71,81.76 85.38,84.42 85.38,91.15 85.25,91.28 85.25,91.66 85.5,91.92 85.76,91.92 86.27,91.41
+V3.3A_SIP on TOP: 79.92,74.77 79.79,74.9 79.79,75.15 79.53,75.41 78.26,75.41 77.76,75.91 77.76,76.29 77.88,76.42 78.26,76.42 78.77,75.91 79.53,75.91 80.04,76.42 80.68,76.42 81.31,77.06 81.31,78.2 81.57,78.45 81.82,78.45 81.95,78.33 81.95,77.95 82.07,77.82 82.58,77.82 82.71,77.95 82.71,81.76 84.11,83.15 86.27,83.15 86.9,83.79 86.9,87.6 87.15,87.85 89.82,87.85 89.95,87.72 89.95,87.34 89.44,86.84 89.06,86.84 88.93,86.71 88.93,86.2 89.19,85.95 89.19,83.66 88.93,83.41 88.42,83.41 85.25,80.23 85.25,76.68 85.76,76.17 85.76,75.15 85.63,75.02 81.69,75.02 81.44,74.77 ; 11 cut-outs
+VCCAMPHYPLL_1P0 on TOP: 73.69,75.66 73.57,75.79 73.57,76.55 73.69,76.68 74.2,76.68 74.45,76.93 75.47,76.93 75.85,76.55 76.23,76.55 76.36,76.42 76.36,76.17 76.11,75.91 74.58,75.91 74.33,75.66
+VCCAPLL_1P0 on TOP: 77.5,76.55 77.38,76.68 77.38,77.56 77.63,77.82 78.14,77.82 78.39,78.07 78.39,80.99 77.88,81.5 77.88,83.03 78.01,83.15 79.03,83.15 79.2,83.33 79.2,84.02 79.28,84.09 79.99,84.09 80.04,84.04 80.04,77.56 79.66,77.18 79.03,77.18 78.39,76.55
+VCCGT on TOP: 75.6,39.85 75.47,39.97 75.47,40.35 75.85,40.73 75.85,41.62 75.98,41.75 75.98,43.15 75.79,43.34 75.28,43.34 74.96,43.66 74.96,46.32 75.22,46.58 75.72,46.58 75.98,46.83 75.98,48.86 75.6,49.24 73.82,49.24 73.57,48.99 72.17,48.99 71.28,48.1 68.36,48.1 67.6,48.86 64.04,48.86 63.66,48.48 63.66,47.59 62.96,46.89 58.77,46.89 56.67,48.99 52.61,48.99 51.59,50.01 51.59,53.56 51.85,53.82 54.13,53.82 54.52,54.2 65.56,54.2 66.33,54.96 71.41,54.96 71.53,54.83 73.57,54.83 73.82,54.58 74.33,54.58 74.45,54.7 74.45,55.21 74.71,55.47 75.72,55.47 75.98,55.21 75.98,54.58 76.11,54.45 78.9,54.45 79.28,54.07 79.28,50.89 79.41,50.77 80.55,50.77 80.8,51.02 81.57,51.02 81.82,50.77 81.82,46.07 82.33,45.56 82.33,44.8 81.19,43.66 81.19,40.99 80.93,40.73 79.53,40.73 79.28,40.48 79.28,39.97 79.15,39.85 ; 46 cut-outs
+VCCGT on TOP: 74.96,56.48 74.58,56.86 74.58,57.75 74.84,58.01 76.61,58.01 76.74,57.88 76.74,57.24 76.61,57.12 76.11,57.12 75.98,56.99 75.98,56.61 75.85,56.48 ; 1 cut-out
+VCCGT on BOTTOM: outline of 89 points within 51.98,34.1 81.82,58.82 ; 24 cut-outs
+VCCGT on L2VCC: 67.29,34.96 61.82,40.43 61.82,42.97 60.94,43.85 59.42,43.85 58.52,44.75 58.52,47.16 56.75,48.93 52.69,48.93 52.04,49.58 52.04,53.48 53.2,54.64 54.85,54.64 55.23,55.02 66.15,55.02 66.66,55.53 70.69,55.53 71.71,54.51 73.64,54.51 74.66,55.53 77.17,55.53 77.69,55.01 77.69,54.63 81.38,50.94 81.38,40.18 80.61,39.42 80.61,37.77 77.8,34.96
+VCCGT on L3: 59.34,46.07 60.1,46.07 61.63,44.54 61.63,39.94 63.23,38.34 63.64,38.34 67.09,34.89 77.25,34.89 78.14,35.78 79.79,35.78 80.8,36.8 80.8,43.91 81.06,44.16 81.06,51.78 77.18,55.66 76.17,55.66 75.85,55.97 75.85,56.74 75.98,56.86 75.98,58.01 75.72,58.26 74.33,58.26 73.57,57.5 70.9,57.5 70.14,56.74 66.45,56.74 65.18,55.47 55.28,55.47 54.52,54.7 53.25,54.7 51.98,53.43 51.98,49.75 52.8,48.93 53.05,48.93 53.37,48.61 56.8,48.61
+VCCGT on L4: 74.33,55.47 75.6,55.47 80.68,50.39 80.68,49.5 80.42,49.24 76.36,49.24 76.11,48.99 74.71,48.99 74.33,49.37 73.18,49.37 73.06,49.5 73.06,49.75 73.69,50.39 73.69,54.83
+VCCGT on L4: 77.12,48.35 80.17,48.35 81.06,47.47 81.06,40.73 80.55,40.23 76.87,40.23 76.61,40.48 76.61,42.77 75.85,43.53 75.85,46.83 76.23,47.21 76.87,47.21 76.99,47.34 76.99,47.72 76.87,47.85 76.87,48.1
+VCCGT on L4: 53.25,53.18 60.74,53.18 61.37,52.55 61.37,47.08 60.99,46.7 58.96,46.7 58.83,46.83 58.83,47.59 57.18,49.24 52.48,49.24 52.36,49.37 52.36,52.29
+VCCGT on L4: 75.85,58.01 75.98,57.88 75.98,56.61 75.85,56.48 74.33,56.48 74.07,56.74 74.07,57.75 74.33,58.01
+VCCGT on L6: 74.58,52.42 75.01,51.99 75.01,50.08 75.47,49.62 75.47,49.24 75.72,48.99 75.72,42.77 75.85,42.64 75.85,39.97 76.23,39.59 79.53,39.59 79.92,39.97 79.92,42.26 81.31,43.66 81.31,46.2 81.06,46.45 80.68,46.45 80.42,46.7 80.42,46.96 80.68,47.21 80.8,47.21 80.93,47.34 80.93,49.75 80.8,49.88 80.8,53.18 80.3,53.69 78.14,53.69 75.98,55.85 75.98,57.75 75.72,58.01 74.33,58.01 74.07,57.75 74.07,55.21 74.58,54.7
+VCCGT on L6: 61.37,48.23 60.36,47.21 58.96,47.21 58.83,47.34 58.83,47.59 57.18,49.24 52.48,49.24 52.36,49.37 52.36,53.82 53.5,54.96 60.48,54.96 61.37,54.07
+VCCIO on TOP: 68.08,87.45 67.98,87.55 67.98,90.26 67.88,90.37 67.12,90.37 66.89,90.14 65.53,90.14 65.52,90.15 65.52,92.5 65.55,92.52 66.63,92.52 66.68,92.47 69.02,92.47 69.15,92.35 69.15,92.12 69.12,92.09 69.12,91.74 69.22,91.64 69.86,91.64 69.88,91.62 69.88,90.9 70.01,90.77 70.64,90.77 70.82,90.6 70.82,87.75 70.52,87.45 ; 3 cut-outs
+VCCIO on TOP: 84.87,57.24 84.74,57.37 84.74,59.02 85.88,60.17 85.88,60.67 86.39,61.18 86.9,61.18 87.15,60.93 87.15,60.42 86.9,60.17 86.65,60.17 86.52,60.04 86.52,59.53 85.63,58.64 85.63,57.37 85.5,57.24
+VCCIO on TOP: 83.34,65.37 83.09,65.63 83.09,66.39 82.84,66.64 82.84,68.42 83.22,68.8 85.25,68.8 85.5,68.55 85.5,66.64 85.25,66.39 85.12,66.39 85,66.26 85,65.75 84.61,65.37 ; 5 cut-outs
+VCCIO on BOTTOM: 83.73,65.37 83.47,65.63 83.47,68.04 83.6,68.17 84.74,68.17 85.12,67.79 85.12,67.75 85.27,67.6 85.59,67.6 85.62,67.63 86.02,67.63 86.06,67.59 86.06,66.39 85.96,66.29 85.28,66.29 84.61,65.63 84.61,65.5 84.49,65.37
+VCCIO on L2VCC: 83.55,65.06 82.15,66.45 81.11,66.45 80.73,66.07 76.44,66.07 76.06,66.45 74.28,66.45 74.14,66.59 74.14,72.69 73.64,73.18 71.36,73.18 69.69,74.85 69.69,75.23 69.07,75.85 67.67,75.85 67.28,76.25 67.28,89.68 67.8,90.2 67.87,90.2 67.91,90.19 67.94,90.2 67.98,90.2 68.01,90.23 69.16,90.79 70.54,90.79 70.83,90.49 70.83,84.22 70.07,83.46 70.07,76.72 71.71,75.09 74.5,75.09 76.68,72.91 76.68,69.99 77.8,68.87 84.41,68.87 84.68,68.6 84.68,65.32 84.41,65.06
+VCCIO on L3: 85.63,65.12 86.14,64.61 86.14,62.96 85.63,62.45 85.63,61.44 86.39,60.67 86.39,59.53 86.01,59.15 84.49,59.15 84.23,59.4 84.23,62.45 85,63.21 85,64.86 84.61,65.25 83.85,65.25 83.6,65.5 83.6,67.66 83.85,67.91 85.38,67.91 85.63,67.66

# Allegro board 14296-1.0727WZS1940.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PC1049  SC22U6D3V3MX-1-GP  [C603H40]  51.09 79.47 0 bottom
PC1050  SC22U6D3V3MX-1-GP  [C603H40]  60.87 73.63 0 top
PC1051  SC22U6D3V3MX-1-GP  [C603H40]  86.01 69.69 90 top
PC1052  SC22U6D3V3MX-1-GP  [C603H40]  74.17 66.85 0 top
PC1053  SC22U6D3V3MX-1-GP  [C603H40]  58.83 78.45 0 bottom
PC1054  SC22U6D3V3MX-1-GP  [C603H40]  60.1 78.45 0 bottom
PC1055  SC10U6D3V3MX-GP  [C603H38]  91.47 60.55 0 top
PC1056  SC10U6D3V3MX-GP  [C603H38]  93.5 56.61 0 top
PC1057  SC10U6D3V3MX-GP  [C603H38]  91.47 66.01 0 top
PC1058  SCD1U25V3KX-GP  [C603H36]  93.38 67.02 180 top
PC1059  SCD1U25V3KX-GP  [C603H36]  91.47 56.61 0 top
PC1060  SCD1U25V3KX-GP  [C603H36]  91.6 63.59 180 top
PC1061  SCD1U25V3KX-GP  [C603H36]  93.38 60.42 0 top
PC1062  SC22U6D3V3MX-1-GP  [C603H40]  94.14 51.66 0 top
PC1063  SC22U6D3V3MX-1-GP  [C603H40]  92.74 51.66 0 top
PC1064  SC22U6D3V5MX-2GP  [C805H58]  132.87 56.86 90 bottom
PC1065  SC22U6D3V3MX-1-GP  [C603H40]  57.06 74.39 180 bottom
PC1066  SC22U6D3V3MX-1-GP  [C603H40]  55.79 74.39 180 bottom
PC1067  SC22U6D3V3MX-1-GP  [C603H40]  54.52 74.39 180 bottom
PC1068  SC22U6D3V3MX-1-GP  [C603H40]  57.56 78.45 0 bottom
PC1069  SC22U6D3V3MX-1-GP  [C603H40]  68.61 51.66 0 top
PC1070  SC22U6D3V3MX-1-GP  [C603H40]  52.23 53.94 180 top
PC1071  SC22U6D3V3MX-1-GP  [C603H40]  81.95 49.12 90 top
PC1072  SC22U6D3V3MX-1-GP  [C603H40]  81.95 50.51 90 top
PC1073  SC22U6D3V3MX-1-GP  [C603H40]  79.28 53.82 90 top
PC1074  SC22U6D3V3MX-1-GP  [C603H40]  69.88 51.66 0 top
PC1075  SC22U6D3V3MX-1-GP  [C603H40]  71.53 34.18 180 bottom
PC1076  SC22U6D3V3MX-1-GP  [C603H40]  69.63 54.91 180 top
PC1077  SC22U6D3V3MX-1-GP  [C603H40]  71.03 54.96 180 top
PC1078  SC22U6D3V3MX-1-GP  [C603H40]  59.68 34.63 90 bottom
PC1079  SC22U6D3V3MX-1-GP  [C603H40]  59.65 37.23 90 bottom
PC1080  SC22U6D3V3MX-1-GP  [C603H40]  59.67 35.92 90 bottom
PC1081  SC22U6D3V3MX-1-GP  [C603H40]  57.69 42.26 90 bottom
PC1082  SC22U6D3V3MX-1-GP  [C603H40]  62.57 51.48 270 bottom
PC1083  SC22U6D3V3MX-1-GP  [C603H40]  62.57 50.21 270 bottom
PC1084  SC22U6D3V3MX-1-GP  [C603H40]  62.57 48.94 270 bottom
PC1085  SC22U6D3V3MX-1-GP  [C603H40]  59.98 54.32 180 top
PC1086  SC22U6D3V3MX-1-GP  [C603H40]  61.25 54.32 180 top
PC1087  SC22U6D3V3MX-1-GP  [C603H40]  62.52 54.32 180 top
PC1088  SC22U6D3V3MX-1-GP  [C603H40]  54.9 54.32 180 top
PC1089  SC22U6D3V3MX-1-GP  [C603H40]  56.17 54.32 180 top
PC1090  SC22U6D3V3MX-1-GP  [C603H40]  57.44 54.32 180 top
PC1091  SC22U6D3V3MX-1-GP  [C603H40]  58.71 54.32 180 top
PC1092  SC22U6D3V3MX-1-GP  [C603H40]  68.23 54.91 180 top
PC1093  SC22U6D3V3MX-1-GP  [C603H40]  72.8 34.18 180 bottom
PC1094  SC22U6D3V3MX-1-GP  [C603H40]  72.83 37.71 0 bottom
PC1095  SC22U6D3V3MX-1-GP  [C603H40]  71.56 37.71 0 bottom
PC1096  SC22U6D3V3MX-1-GP  [C603H40]  70.29 37.71 0 bottom
PC1097  SC22U6D3V3MX-1-GP  [C603H40]  72.3 67.66 0 top
PC1098  SC22U6D3V3MX-1-GP  [C603H40]  58.36 74.39 180 bottom
PC4301  SCD1U25V3KX-GP  [C603H36]  34.58 28.54 180 bottom
PC4302  SC1U25V3KX-1-GP  [C603H36]  41.25 29.84 180 bottom
PC4303  SCD01U50V2KX-1GP  [C402H22]  34.07 23.21 90 bottom
PC4304  SCD01U50V2KX-1GP  [C402H22]  34.07 22.32 90 bottom
PC4305  SCD01U50V2KX-1GP  [C402H22]  34.07 21.43 90 bottom
PC4306  SC10U25V5KX-GP  [C805H56]  34.32 25.24 0 bottom
PC4401  SCD1U25V2KX-GP  [C402H22]  47.02 16.48 180 top
PC4402  SCD01U50V2KX-1GP  [C402H22]  35.85 11.52 180 top
PC4403  SC10U25V5KX-GP  [C805H56]  69.78 29.15 270 bottom
PC4407  SC10U25V5KX-GP  [C805H56]  46.13 25.62 0 bottom
PC4408  SC10U25V5KX-GP  [C805H56]  69.4 32.94 270 bottom
PC4409  SC10U25V5KX-GP  [C805H56]  69.78 31.06 270 bottom
PC4410  SC1U25V3KX-1-GP  [C603H36]  36.61 18.38 90 bottom
PC4411  SC10U25V5KX-GP  [C805H56]  43.34 20.29 90 bottom
PC4412  SCD1U25V2KX-GP  [C402H22]  47.02 14.7 0 top
PC4413  SCD1U25V2KX-GP  [C402H22]  47.53 26.13 0 bottom
PC4414  SC2K2P50V2KX-L-GP  [C402H22]  54.95 26.16 270 top
PC4415  SC10U25V5KX-GP  [C805H56]  77.78 27.96 0 bottom
PC4416  SCD1U25V2KX-GP  [C402H22]  35.47 16.22 90 bottom
PC4418  SCD1U25V2KX-GP  [C402H22]  33.69 15.08 270 bottom
PC4420  SC1U25V3KX-1-GP  [C603H36]  74.96 23.46 270 top
PC4421  SCD047U25V2KX-GP  [C402H22]  38.77 18.64 0 top
PC4422  SC2D2U10V3KX-1GP  [C603H36]  41.56 18.64 180 top
PC4424  SCD01U50V2KX-1GP  [C402H22]  82.2 27.4 90 bottom
PC4425  SC10U25V5KX-GP  [C805H56]  49.56 17.37 180 bottom
PC4427  SC10U25V5KX-GP  [C805H56]  51.59 17.37 180 bottom
PC4428  SCD1U25V2KX-GP  [C402H22]  35.85 14.95 180 bottom
PC4429  SCD1U25V2KX-GP  [C402H22]  47.91 15.59 0 top
PC4430  SC10U25V5KX-GP  [C805H56]  69.25 22.7 180 bottom
PC4432  SC1U25V3KX-1-GP  [C603H36]  33.31 16.22 90 bottom
PC4433  SCD1U25V2KX-GP  [C402H22]  36.23 17.24 90 bottom
PC4434  SC10U25V5KX-GP  [C805H56]  47.66 17.37 180 bottom
PC4435  SC100P50V2JN-3GP  [C402H22]  38.64 10.89 180 bottom
PC4436  SC100P50V2JN-3GP  [C402H22]  36.86 7.33 180 bottom
PC4437  SC100P50V2JN-3GP  [C402H22]  37.75 7.33 180 bottom
PC4438  SC1U25V3KX-1-GP  [C603H36]  46.26 9.62 90 bottom
PC4439  SC10U25V5KX-GP  [C805H56]  74.96 23.46 90 bottom
PC4440  SC10U25V5KX-GP  [C805H56]  79.58 27.96 0 bottom
PC4441  SC10U25V5KX-GP  [C805H56]  41.72 40.44 90 bottom
PC4442  SC10U25V5KX-GP  [C805H56]  49.89 37.97 0 bottom
PC4509  SC10U25V5KX-GP  [C805H56]  36.48 75.28 0 bottom
PC4511  SC10U25V5KX-GP  [C805H56]  35.85 69.82 180 bottom
PC4512  SC10U25V5KX-GP  [C805H56]  33.94 69.82 180 bottom
PC4513  SCD01U50V2KX-L-GP  [C402H22]  32.54 70.83 180 top
PC4515  SC10U25V5KX-GP  [C805H56]  31.12 73.3 0 bottom
PC4517  SCD1U50V3KX-L-GP  [C603H36]  36.23 66.39 90 bottom
PC4518  SCD1U50V3KX-L-GP  [C603H36]  26.98 66.21 180 bottom
PC4519  SCD1U16V2KX-L-GP  [C402H22]  33.18 88.49 90 bottom
PC4520  SCD1U16V2KX-L-GP  [C402H22]  24.42 90.39 90 bottom
PC4522  SC10U25V5KX-GP  [C805H56]  29.29 70.4 180 bottom
PC4524  SC4D7U6D3V3KX-GP  [C603H36]  31.45 71.29 180 top
PC4527  SC4D7U6D3V3KX-GP  [C603H36]  31.53 61.94 0 top
PC4601  SCD01U50V2KX-1GP  [C402H22]  37.88 53.05 0 top
PC4602  SC4700P50V2KX-1GP  [C402H22]  36.35 42.89 90 top
PC4603  SC1KP50V2KX-1GP  [C402H22]  34.58 43.35 180 bottom
PC4604  SC15P50V2JN-L-GP  [C402H22]  35.08 43.91 0 top
PC4605  SC1KP50V2KX-1GP  [C402H22]  33.05 42.89 270 bottom
PC4606  SC4700P50V2KX-1GP  [C402H22]  35.85 43.78 270 bottom
PC4607  SC2200P50V2KX-2GP  [C402H22]  35.85 44.67 270 bottom
PC4608  SC1KP50V2KX-1GP  [C402H22]  32.67 44.29 180 bottom
PC4609  SC470P50V2KX-3GP  [C402H22]  35.85 46.7 0 top
PC4610  SCD1U25V2KX-GP  [C402H22]  41.43 43.27 180 bottom
PC4611  SC1KP50V2KX-1GP  [C402H22]  32.67 44.29 0 top
PC4612  SC2200P50V2KX-2GP  [C402H22]  30.77 44.29 0 top
PC4613  SC220P50V2KX-3GP  [C402H22]  36.61 48.1 90 top
PC4614  SC470P50V2KX-3GP  [C402H22]  28.99 47.97 0 top
PC4615  SC470P50V2KX-3GP  [C402H22]  31.43 48.1 90 top
PC4616  SCD033U25V2KX-GP  [C402H22]  40.04 50.39 0 bottom
PC4617  SC10P50V2JN-4GP  [C402H22]  28.86 47.85 0 bottom
PC4618  SC2200P50V2KX-2GP  [C402H22]  27.59 48.23 270 bottom
PC4619  SC150P50V2JN-3GP  [C402H22]  36.61 51.58 90 top
PC4620  SC1KP50V2KX-1GP  [C402H22]  27.21 50.39 0 bottom
PC4621  SC56P50V2JN-2GP  [C402H20]  28.1 50.39 0 bottom
PC4622  SC1KP50V2KX-1GP  [C402H22]  37.5 55.21 0 top
PC4623  SCD047U25V2KX-GP  [C402H22]  28.99 53.05 0 bottom
PC4625  SC1KP50V2KX-1GP  [C402H22]  35.72 55.34 180 top
PC4626  SCD01U50V2KX-1GP  [C402H22]  31.27 50.39 90 top
PC4627  SC1KP50V2KX-1GP  [C402H22]  34.32 56.61 270 top
PC4628  SCD1U25V2KX-GP  [C402H22]  34.96 52.16 0 top
PC4629  SCD01U50V2KX-1GP  [C402H22]  32.42 52.04 0 top
PC4630  SCD1U25V2KX-GP  [C402H22]  31.53 51.66 0 top
PC4631  SC1U10V2KX-1GP  [C402H22]  33.31 52.04 0 top
PC4632  SC1KP50V2KX-1GP  [C402H22]  33.51 47.34 180 top
PC4633  SC1KP50V2KX-1GP  [C402H22]  36.61 50.77 90 top
PC4634  SC2200P50V2KX-2GP  [C402H22]  39.15 50.39 0 bottom
PC4701  SC10U25V5KX-GP  [C805H56]  37.88 60.04 90 bottom
PC4702  SC10U25V5KX-GP  [C805H56]  37.88 58.13 90 bottom
PC4703  SC10U25V5KX-GP  [C805H56]  37.88 56.23 90 bottom
PC4704  SC10U25V5KX-GP  [C805H56]  43.34 52.16 270 bottom
PC4705  SC10U25V5KX-GP  [C805H56]  43.59 53.99 270 bottom
PC4706  SCD22U25V3KX-GP  [C603H40]  38.89 61.69 270 bottom
PC4707  SC2D2U10V3KX-1GP  [C603H36]  46.01 64.24 0 bottom
PC4708  SC1U10V2KX-1GP  [C402H22]  44.51 64.66 270 bottom
PC4709  SC330P50V3KX-GP  [C603]  46.64 57.63 0 top
PC4710  SCD1U25V2KX-GP  [C402H22]  43.47 55.34 270 bottom
PC4802  SC10U25V5KX-GP  [C805H56]  47.53 41.5 270 bottom
PC4803  SC10U25V5KX-GP  [C805H56]  41.72 38.54 90 bottom
PC4804  SC10U25V5KX-GP  [C805H56]  47.53 39.59 270 bottom
PC4805  SC10U25V5KX-GP  [C805H56]  41.72 36.63 90 bottom
PC4806  SC10U25V5KX-GP  [C805H56]  44.28 46.48 0 bottom
PC4807  SC2D2U10V3KX-1GP  [C603H36]  50.45 53.43 0 bottom
PC4808  SC1U10V2KX-1GP  [C402H22]  47.91 53.18 0 bottom
PC4809  SCD22U25V3KX-GP  [C603H40]  43.47 48.86 270 bottom
PC4810  SCD1U25V2KX-GP  [C402H22]  47.4 42.89 270 bottom
PC5001  SC2D2U10V3KX-1GP  [C603H36]  42.2 66.64 0 bottom
PC5002  SC10U25V5KX-GP  [C805H56]  40.25 74.74 0 bottom
PC5003  SC10U25V5KX-GP  [C805H56]  38.39 74.77 0 bottom
PC5004  SCD1U25V2KX-GP  [C402H22]  41.69 74.52 0 bottom
PC5005  SCD22U25V3KX-GP  [C603H40]  45.37 70.28 90 bottom
PC5101  SC22U6D3V5MX-2GP  [C805H58]  139.61 54.32 270 bottom
PC5102  SCD1U16V2KX-3GP  [C402H22]  133.13 51.66 90 bottom
PC5103  SC22U6D3V5MX-2GP  [C805H58]  139.61 56.23 270 bottom
PC5104  SC22U6D3V5MX-2GP  [C805H58]  132.87 53.05 90 bottom
PC5105  SC22U6D3V5MX-2GP  [C805H58]  132.87 54.96 90 bottom
PC5106  SC10U25V5KX-GP  [C805H56]  141.51 42.51 0 bottom
PC5107  SCD01U50V2KX-1GP  [C402H22]  140.11 43.02 0 bottom
PC5108  SC10U25V5KX-GP  [C805H56]  137.07 40.99 90 bottom
PC5110  SC1U10V2KX-1GP  [C402H22]  136.18 40.86 0 top
PC5111  SC1U10V2KX-1GP  [C402H22]  135.54 82.19 270 bottom
PC5112  SC220P50V2KX-3GP  [C402H22]  132.49 42.56 180 bottom
PC5113  SC1U10V2KX-1GP  [C402H22]  133.76 41.19 90 bottom
PC5114  SC22U6D3V3MX-1-GP  [C603H40]  134.02 75.02 90 top
PC5115  SC10U6D3V3MX-GP  [C603H38]  135.92 72.74 270 bottom
PC5116  SCD1U16V2KX-3GP  [C402H22]  133.26 81.5 90 bottom
PC5117  SCD1U25V2KX-GP  [C402H22]  137.57 44.8 180 top
PC5118  SCD1U16V2KX-3GP  [C402H22]  136.05 73.88 270 bottom
PC5119  SCD1U16V2KX-3GP  [C402H22]  133.97 81.78 0 top
PC5120  SCD1U16V2KX-3GP  [C402H22]  132.95 83 90 bottom
PC5138  SCD1U16V2KX-3GP  [C402H22]  133.76 46.45 90 bottom
PC5214  SC10U25V5KX-GP  [C805H56]  39.4 84.3 90 bottom
PC5215  SCD01U50V2KX-L-GP  [C402H22]  42.45 82.77 270 bottom
PC5216  SC10U25V5KX-GP  [C805H56]  42.58 81.37 270 bottom
PC5217  SCD1U25V2KX-GP  [C402H22]  46.13 87.22 90 top
PC5218  SC220P50V2KX-3GP  [C402H22]  41.31 89.5 180 bottom
PC5219  SC1U10V2KX-1GP  [C402H22]  39.66 86.07 90 bottom
PC5220  SC1KP50V2KX-1GP  [C402H22]  46.46 89.25 0 bottom
PC5221  SCD1U10V2KX-5GP  [C402H22]  54.85 86.43 0 bottom
PC5222  SC22U6D3V5MX-2GP  [C805H58]  56.17 86.84 0 bottom
PC5223  SC22U6D3V5MX-2GP  [C805H58]  58.07 86.84 0 bottom
PC5224  SC22U6D3V5MX-2GP  [C805H58]  58.2 82.14 180 bottom
PC5225  SC22U6D3V5MX-2GP  [C805H58]  56.29 82.14 180 bottom
PC5226  SC2D2U10V3KX-1GP  [C603H36]  40.16 89.88 0 bottom
PC5301  SC1U10V2KX-1GP  [C402H22]  34.58 3.14 270 bottom
PC5302  SC22U6D3V5MX-2GP  [C805H58]  35.97 9.11 270 bottom
PC5303  SC10U6D3V3MX-GP  [C603H38]  35.97 4.41 270 bottom
PC5304  SC22U6D3V5MX-2GP  [C805H58]  35.97 11.14 270 bottom
PC5305  SC68P50V2JN-1GP  [C402H22]  30.39 13.43 0 bottom
PC5306  SC4700P50V2KX-1GP  [C402H22]  29.24 2.18 90 bottom
PC5307  SCD1U16V2KX-3GP  [C402H22]  14.13 72.74 90 bottom
PC5308  SC1U10V2KX-1GP  [C402H22]  14.51 71.47 0 bottom
PC5309  SC1U10V2KX-1GP  [C402H22]  20.1 71.09 0 bottom
PD4301  PESD24VS2UT-GP  [SOT-23-10H44]  22.13 95.09 270 top
PD4302  DA3X101F0L-1-GP  [SOT23-2D8-312H56]  39.53 100.93 180 top
PD4303  1SMB22AT3G-GP-U1  [D5436AKH98]  39.53 33.37 90 bottom
PD4304  SMF18AT1G-GP  [SOD123FLAKH40]  89.44 25.37 270 top
PD4401  CH035H-40PT0-GP  [SOD323AKH40]  43.34 18.51 180 top
PD4402  V8P10-5300M3-86A-GP  [SMPC4665-3P-UH48]  85.12 25.9 90 top
PD4405  CH035H-40PT0-GP  [SOD323AKH40]  30.26 18.51 0 bottom
PD4406  CH035H-40PT0-GP  [SOD323AKH40]  31.53 23.21 180 bottom
PG4401  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  41.18 7.71 270 top
PG4402  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  43.72 25.88 90 bottom
PG4403  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  74.71 25.62 0 bottom
PG4406  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  42.7 25.88 90 bottom
PG4407  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  71.41 25.62 180 bottom
PG4408  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  40.16 7.71 270 top
PG4410  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  41.05 15.21 90 bottom
PG4530  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  36.74 85.69 0 bottom
PG4531  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  25.43 85.69 180 bottom
PG4532  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  25.43 84.67 180 bottom
PG4533  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  30.33 61.44 90 top
PG4534  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  29.88 70.45 180 top
PG4601  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  30 55.34 180 top
PG4707  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  50.45 59.02 270 bottom
PG4708  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  50.45 61.82 90 bottom
PG4808  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  54.9 46.2 270 bottom
PG4809  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  54.9 48.99 90 bottom
PG5001  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  51.47 75.79 0 bottom
PG5011  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  49.94 75.79 180 bottom
PG5209  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  59.47 86.2 90 bottom
PG5304  -  [GAP-CLOSE-PWR]  21.24 70.58 0 bottom
PL4401  COIL-2D2UH-11-GP  [L11510030H158]  61.25 24.1 270 bottom
PL4501  IND-3D3UH-57-GP-U  [L7066-1830-UH119]  27.74 79.47 0 bottom
PL4502  IND-1D5UH-71-GP-U  [L4240-D815-UH79]  34.07 80.87 180 bottom
PL4701  IND-D15UH-11-GP  [L6965-1530H158]  50.45 60.42 0 bottom
PL4801  IND-D15UH-11-GP  [L6965-1530H158]  55.02 47.59 0 bottom
PL5001  COIL-D47UH-9-GP  [L4240-D815-UH79]  50.71 75.79 270 bottom
PL5101  COIL-1UH-73-GP  [L4947-1115H119]  137.57 49.88 0 bottom
PL5202  IND-D68UH-36-GP-U  [L686647-127318H119]  49.92 84.4 270 bottom
PQ4301  CH3904PT-GP  [SOT23CBE2D6H46]  35.72 101.06 90 top
PQ4302  FDV301N-NL-GP  [SOT23DGS2D4H44]  35.63 97.03 0 top
PQ4407  2N7002KDW-GP  [SOT-363H44]  38.16 25.83 270 top
PR4301  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  15.38 93.29 180 top
PR4302  15KR2F-GP  [R402H16]  33.18 99.38 180 top
PR4303  10KR2J-3-GP  [R402H16]  33.31 96.61 180 top
PR4304  100KR2J-1-GP  [R402H16]  33.31 102.08 0 top
PR4305  2K2R2J-2-GP  [R402H16]  41.74 100.53 0 top
PR4306  33R2J-2-GP  [R402H16]  36.44 94.72 90 top
PR4308  240KR3-GP  [R603H22]  42.54 29.84 180 bottom
PR4309  47KR3J-L-GP  [R603H22]  42 28 270 bottom
PR4403  10R5J-GP  [R805H24]  33.94 18.64 270 bottom
PR4404  120KR2J-GP  [R402H16]  38.49 5.05 0 bottom
PR4408  20R3F-L-GP  [R603H22]  46.77 11.52 0 bottom
PR4409  1KR2F-3-GP  [R402H16]  44.99 13.18 90 top
PR4410  100KR2J-1-GP  [R402H16]  37.6 5.05 180 bottom
PR4411  47KR2F-GP  [R402H16]  34.96 11.52 180 top
PR4413  0R2J-2-GP  [R402H16]  42.2 7.59 180 top
PR4414  3K3R2J-3-GP  [R402H16]  39.4 5.05 0 bottom
PR4415  0R2J-2-GP  [R402H16]  43.09 7.59 180 top
PR4417  0R0402-PAD-2-GP  [0R0402-PAD-1]  45.75 15.08 90 top
PR4418  3K3R6J-GP  [R1206H28]  38.04 22.07 180 top
PR4419  4D7R3F-L-GP  [R603H22]  51.9 26.16 270 top
PR4421  0R2J-2-GP  [R402H16]  34.96 14.95 180 bottom
PR4423  10KR2F-2-GP  [R402H16]  40.42 23.97 0 top
PR4424  100KR2F-L1-GP  [R402H16]  42.7 10.13 0 bottom
PR4425  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  40.16 18.64 180 top
PR4426  D01R3721F-GP-U  [R3720H40]  43.21 23.72 270 bottom
PR4432  3K3R2J-3-GP  [R402H16]  40.29 5.05 0 bottom
PR4435  100KR2J-1-GP  [R402H16]  40.8 22.57 270 top
PR4438  0R0402-PAD-2-GP  [0R0402-PAD-1]  45.75 16.1 90 top
PR4439  4K02R2F-GP  [R402H16]  35.47 13.68 270 bottom
PR4443  D01R2512F-3-GP  [R2512H32]  73.06 26.26 270 bottom
PR4444  287KR2F-GP  [R402H16]  35.59 9.49 270 top
PR4445  33KR2F-GP  [R402H16]  44.48 10.13 180 bottom
PR4449  100KR2J-1-GP  [R402H16]  44.48 11.91 180 bottom
PR4468  150KR2F-L-GP  [R402H16]  43.59 10.13 0 bottom
PR4469  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.53 7.33 0 bottom
PR4470  100KR2J-1-GP  [R402H16]  45.75 18.13 0 top
PR4471  100KR2J-1-GP  [R402H16]  47.02 17.87 90 top
PR4472  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.53 10.89 0 bottom
PR4473  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.97 7.21 0 bottom
PR4474  0R0402-PAD-2-GP  [0R0402-PAD-1]  38.64 7.33 0 bottom
PR4475  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.47 12.79 270 bottom
PR4501  16KR2F-GP  [R402H16]  35.47 62.32 0 top
PR4502  62KR2F-GP  [R402H16]  30 65.75 0 bottom
PR4503  200R2J-L1-GP  [R402H16]  29.12 64.99 0 bottom
PR4508  1D5R3F-GP  [R603H22]  36.23 67.66 90 bottom
PR4509  1D5R3F-GP  [R603H22]  26.68 68.27 90 bottom
PR4512  6K65R2F-GP  [R402H16]  33.69 62.32 180 top
PR4515  15KR2F-GP  [R402H16]  30.51 62.83 270 bottom
PR4517  10KR2F-L1-GP  [R402H15]  32.8 62.32 0 top
PR4519  100KR2J-4-GP  [R402H15]  33.05 64.36 0 bottom
PR4520  9K76R2F-1-GP  [R402H16]  30.89 64.23 0 bottom
PR4521  0R0402-PAD-2-GP  [0R0402-PAD-1]  27.34 64.1 180 bottom
PR4522  100KR2J-1-GP  [R402H16]  32.16 64.36 0 bottom
PR4527  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.47 64.86 180 bottom
PR4601  1KR2F-3-GP  [R402H16]  38.01 54.83 90 bottom
PR4602  2KR2F-3-GP  [R402H16]  36.86 44.16 180 top
PR4604  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.21 39.85 270 bottom
PR4605  825R2F-GP  [R402H16]  33.56 44.29 180 bottom
PR4606  NTC-100K-1-GP-U  [NTC-402H24-U]  50.45 72.74 270 bottom
PR4607  0R0402-PAD-2-GP  [0R0402-PAD-1]  32.16 40.1 0 bottom
PR4608  787R2F-GP  [R402H16]  31.78 44.29 180 bottom
PR4609  14KR2F-GP  [R402H16]  36.48 42.89 270 bottom
PR4611  14K7R2F-L-GP  [R402H16]  34.96 47.21 180 top
PR4612  7K5R3F-2-GP  [R603H22]  36.35 41.75 270 bottom
PR4613  34KR2F-GP  [R402H16]  35.59 45.43 90 top
PR4614  10KR2F-2-GP  [R402H16]  38.7 38.28 270 bottom
PR4615  20KR2F-L-GP  [R402H16]  32.7 47.34 180 top
PR4617  0R0402-PAD-2-GP  [0R0402-PAD-1]  33.56 43.53 180 top
PR4618  0R0402-PAD-2-GP  [0R0402-PAD-1]  32.67 42.51 180 top
PR4619  1KR2F-3-GP  [R402H16]  31.78 44.29 0 top
PR4621  45D3R2F-L-GP  [R402H16]  39.53 45.05 0 bottom
PR4622  75R2F-2-GP  [R402H16]  40.42 45.05 0 bottom
PR4623  100R2F-L1-GP-U  [R402H14]  41.31 45.05 180 bottom
PR4624  1KR2F-3-GP  [R402H16]  65.28 39.08 270 bottom
PR4625  37D4R2F-GP  [R402H16]  28.1 47.97 180 top
PR4626  1KR2F-3-GP  [R402H16]  28.61 46.58 90 bottom
PR4627  7K5R3F-2-GP  [R603H22]  39.4 52.42 0 bottom
PR4628  105KR2F-1-GP  [R402H16]  36.61 48.99 270 top
PR4629  14KR2F-GP  [R402H16]  41.3 50.08 90 bottom
PR4630  0R0402-PAD-2-GP  [0R0402-PAD-1]  38.64 44.42 180 bottom
PR4631  4K75R2F-1-GP  [R402H16]  27.59 47.42 90 bottom
PR4632  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.85 42.03 270 top
PR4633  NTC-100K-1-GP-U  [NTC-402H24-U]  48.04 55.21 270 bottom
PR4634  NTC-220K-5-GP-U  [NTC-402H24-U]  50.2 42.89 90 bottom
PR4635  51KR2F-L-GP  [R402H16]  36.61 49.88 270 top
PR4636  1K5R2F-2-GP  [R402H16]  36.61 52.39 90 top
PR4637  59KR3F-GP  [R603H22]  27.72 51.02 0 top
PR4638  165KR2F-GP  [R402H16]  27.21 48.99 180 top
PR4639  75KR2F-GP  [R402H16]  28.61 49.37 90 top
PR4640  12K4R2F-GP  [R402H16]  27.72 49.12 90 bottom
PR4644  422R2F-2-GP  [R402H16]  36.61 55.21 0 top
PR4645  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.08 57.88 0 top
PR4646  10R2F-L-GP  [R402H14]  28.86 53.94 180 top
PR4647  3K48R2F-GP  [R402H16]  34.83 55.34 180 top
PR4648  0R0402-PAD-2-GP  [0R0402-PAD-1]  34.2 57.88 0 top
PR4650  0R0402-PAD-2-GP  [0R0402-PAD-1]  34.12 52.98 180 top
PR4651  4K87R2F-GP  [R402H16]  27.59 53.43 90 bottom
PR4652  6K65R2F-GP  [R402H16]  32.67 54.96 270 top
PR4653  NTC-100K-1-GP-U  [NTC-402H24-U]  41.05 63.85 90 bottom
PR4655  0R0402-PAD-2-GP  [0R0402-PAD-1]  29.37 54.7 270 bottom
PR4656  NTC-100K-1-GP-U  [NTC-402H24-U]  46.64 51.4 90 bottom
PR4657  2D2R2J-GP  [R402H16]  31.27 55.09 0 top
PR4658  90K9R2F-GP  [R402H16]  33.81 57.1 0 bottom
PR4659  24KR2F-GP  [R402H16]  31.93 56.51 0 bottom
PR4660  15K8R2F-GP  [R402H16]  34.65 56.46 0 bottom
PR4661  6K65R2F-GP  [R402H16]  29.37 55.59 270 bottom
PR4662  48D7KR2F-GP  [R402H16]  32.77 56.51 0 bottom
PR4663  10KR2F-2-GP  [R402H16]  35.64 55.95 0 bottom
PR4664  24KR2F-GP  [R402H16]  31.12 56.05 0 bottom
PR4665  49D9R2F-L1-GP  [R402H16]  39.66 46.45 90 bottom
PR4666  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.66 47.34 90 bottom
PR4667  10R2F-L-GP  [R402H14]  39.66 48.23 90 bottom
PR4668  100R2F-L1-GP-U  [R402H14]  39.66 49.12 270 bottom
PR4669  2K49R2F-GP  [R402H16]  33.94 55.34 0 top
PR4670  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.56 43.16 270 bottom
PR4671  1KR2F-3-GP  [R402H16]  27.72 52.55 270 bottom
PR4672  0R0402-PAD-2-GP  [0R0402-PAD-1]  35.97 44.16 0 top
PR4701  3D9R3-GP  [R603H22]  38.89 63.09 270 bottom
PR4702  2D2R2F-GP  [R402H16]  42.69 64.61 0 bottom
PR4703  0R0402-PAD-2-GP  [0R0402-PAD-1]  41.18 64.86 90 bottom
PR4704  2D2R5F-2-GP  [R805H24]  49.31 58.39 270 top
PR4802  3D9R3-GP  [R603H22]  43.47 50.26 90 bottom
PR4803  2D2R2F-GP  [R402H16]  48.8 53.18 0 bottom
PR4807  0R0402-PAD-2-GP  [0R0402-PAD-1]  47.02 53.18 0 bottom
PR5001  2D2R3-1-U-GP  [R603H22]  46.87 68.27 180 bottom
PR5101  2D2R3-1-U-GP  [R603H22]  136.94 43.27 90 top
PR5102  0R0402-PAD-2-GP  [0R0402-PAD-1]  137.07 40.86 0 top
PR5103  150KR2F-L-GP  [R402H16]  133.76 42.84 270 bottom
PR5104  120KR2F-L-GP  [R402H16]  133.76 43.66 90 bottom
PR5105  0R0402-PAD-2-GP  [0R0402-PAD-1]  133.76 47.34 270 bottom
PR5106  0R2J-2-GP  [R402H16]  133.76 45.56 270 bottom
PR5107  0R0402-PAD-2-GP  [0R0402-PAD-1]  135.03 43.91 180 top
PR5108  1KR2F-3-GP  [R402H16]  133.76 42.03 270 bottom
PR5110  1KR2J-1-GP  [R402H16]  134.14 43.91 180 top
PR5111  0R2J-2-GP  [R402H16]  134.27 83.79 180 bottom
PR5114  0R0402-PAD-2-GP  [0R0402-PAD-1]  135.59 81.83 180 top
PR5117  0R2J-2-GP  [R402H16]  135.54 83.03 270 bottom
PR5118  0R2J-2-GP  [R402H16]  135.67 83.91 270 bottom
PR5119  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  133.56 76.93 180 top
PR5125  0R0402-PAD-2-GP  [0R0402-PAD-1]  132.95 83.84 270 bottom
PR5209  0R0402-PAD-2-GP  [0R0402-PAD-1]  43.97 89.25 180 bottom
PR5210  2D2R3J-2-GP  [R603H22]  43.97 87.22 90 top
PR5211  0R0402-PAD-2-GP  [0R0402-PAD-1]  44.81 89.25 180 bottom
PR5212  100KR2J-1-GP  [R402H16]  45.63 89.25 180 bottom
PR5213  100KR2F-L1-GP  [R402H16]  43.09 89.25 0 bottom
PR5214  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.66 86.91 90 bottom
PR5215  0R0402-PAD-2-GP  [0R0402-PAD-1]  50.53 89.17 180 bottom
PR5216  68KR2F-GP  [R402H16]  42.2 89.5 180 bottom
PR5217  0R2J-L-GP  [R402H15]  51.37 89.17 180 bottom
PR5301  47KR2J-2-GP  [R402H16]  29.24 3.07 90 bottom
PR5302  100KR2F-L1-GP  [R402H16]  32.7 2.3 90 bottom
PR5303  16K5R2F-2-GP  [R402H16]  31.27 13.43 0 bottom
PR5304  13K3R2F-L1-GP  [R402H16]  29.5 13.43 0 bottom
PR5305  0R0402-PAD-2-GP  [0R0402-PAD-1]  13.75 73.75 270 bottom
PR5306  0R0402-PAD-2-GP  [0R0402-PAD-1]  30.51 2.63 0 bottom
PR5307  0R2J-2-GP  [R402H16]  31.4 2.63 0 bottom
PR5308  0R0402-PAD-2-GP  [0R0402-PAD-1]  32.7 3.12 90 bottom
PT4501  ST220U6D3VBM-3-GP  [CT3528H79]  27.85 87.47 0 bottom
PT4502  ST220U6D3VBM-3-GP  [CT3528H79]  33.43 85.69 90 bottom
PT4701  ST330U2D5VBM-1-GP  [CT3528H79]  52.61 68.55 0 bottom
PT4702  ST33U25VDM-2-GP  [CT7343H119]  47 31.83 180 bottom
PT4703  ST330U2D5VBM-1-GP  [CT3528H79]  49.18 68.55 0 bottom
PT4801  ST330U2D5VBM-1-GP  [CT3528H79]  61.63 53.82 270 bottom
PT4802  ST330U2D5VBM-1-GP  [CT3528H79]  54.64 53.82 90 bottom
PT4803  ST33U25VDM-2-GP  [CT7343H119]  54.64 36.92 0 bottom
PU4301  SI7121DN-T1-GE3-GP  [PPAK-8P-2H45]  37.5 26.76 0 bottom
PU4401  BQ24770RUYR-3-GP  [QFN28-G2D7H32]  40.16 13.3 90 top
PU4403  SI7121DN-T1-GE3-GP  [PPAK-8P-2H45]  83.98 24.73 90 bottom
PU4405  SI7121DN-T1-GE3-GP  [PPAK-8P-2H45]  37.75 22.57 270 bottom
PU4406  FDMS3600-02-RJK0215-COLAY-GP  [PPAK-8P-G5324H44-COLAY]  51.09 23.08 180 bottom
PU4501  CSD87381P-GP  [SON5Z3025H18]  26.63 72.89 90 bottom
PU4502  CSD87381P-GP  [SON5Z3025H18]  33.81 75.53 90 bottom
PU4503  TPS51225RUKR-GP  [QFN20-G1D75H32]  31.4 66.9 180 top
PU4601  NCP81208MNTXG-2-GP  [LFQFN48J6-G4D6H40]  34.2 49.75 270 bottom
PU4701  NCP81382MNTXG-1-GP  [QFN36J4060-G2554H40]  43.85 59.4 180 bottom
PU4803  NCP81382MNTXG-1-GP  [QFN36J4060-G2554H40]  48.42 47.08 180 bottom
PU5001  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  44.08 73.63 270 bottom
PU5002  NCP81253MNTBG-GP-U2  [LFDFN8G2-G1309H40]  44.48 67.21 0 bottom
PU5003  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  45.6 78.2 90 bottom
PU5101  SY8206DQNC-GP-U  [QFN10M3-G4P-UH34]  137.45 44.16 180 bottom
PU5102  APL5338XAI-TRG-GP  [MSOP10-G2D5H44]  134.78 77.69 180 bottom
PU5202  SY8208DQNC-GP-U  [QFN10M3-G4P-UH34]  43.09 85.44 90 bottom
PU5301  APL5930KAI-TRG-GP  [SOIC8-G3530H63]  31.4 7.59 0 bottom
PU5302  S-1339D15-M5001-GP  [SOT-23-5H52]  17.3 71.6 90 bottom
Q1701  2N7002KDW-GP  [SOT-363H44]  111.41 94.33 0 top
Q1702  2N7002KDW-GP  [SOT-363H44]  151.98 37.92 180 bottom
Q1801  2N7002KDW-GP  [SOT-363H44]  104.55 94.2 0 top
Q1802  2N7002K-2-GP  [SOT23DGS2D4H44]  107.98 94.33 180 top
Q2408  2N7002K-2-GP  [SOT23DGS2D4H44]  143.16 34.77 0 bottom
Q2412  2N7002K-2-GP  [SOT23DGS2D4H44]  143.16 38.58 180 bottom
Q2413  2N7002K-2-GP  [SOT23DGS2D4H44]  134.86 37.74 180 bottom
Q2414  2N7002K-2-GP  [SOT23DGS2D4H44]  150.02 28.42 180 bottom
Q2415  2N7002K-2-GP  [SOT23DGS2D4H44]  16.59 54.45 180 bottom
Q2505  2N7002K-2-GP  [SOT23DGS2D4H44]  140.75 65.37 0 top
Q2601  2N7002KDW-GP  [SOT-363H44]  101.51 94.2 0 top
Q2602  2N7002K-2-GP  [SOT23DGS2D4H44]  98.08 30.4 270 bottom
Q2603  CH3904PT-GP  [SOT23CBE2D6H46]  99.73 106.77 0 bottom
Q2604  2N7002KDW-GP  [SOT-363H44]  143.54 70.07 0 top
Q4006  DMP2130L-7-GP  [SOT23DGS2D4H48]  23.78 33.62 90 bottom
Q4007  2N7002K-2-GP  [SOT23DGS2D4H44]  22.51 37.43 0 bottom
Q5502  2N7002K-2-GP  [SOT23DGS2D4H44]  39.42 97.04 180 top
Q5704  2N7002K-2-GP  [SOT23DGS2D4H44]  17.3 67.53 180 top
Q6501  P8503BMG-GP  [SOT23DGS2D8H56]  21.37 10.51 270 top
Q6502  DMP2130L-7-GP  [SOT23DGS2D4H48]  102.32 24.35 90 bottom
Q6503  2N7002K-2-GP  [SOT23DGS2D4H44]  121.83 20.54 270 bottom
Q6504  2N7002KDW-GP  [SOT-363H44]  121.83 23.84 270 bottom
Q6505  DDTA144VCA-7-F-GP  [SOT23CBE2D4H44]  144.69 28.42 0 bottom
Q7001  2N7002KDW-GP  [SOT-363H44]  152.05 17.75 180 bottom
R401  1KR2J-1-GP  [R402H16]  65.28 39.9 270 bottom
R402  51R2J-2-GP  [R402H16]  110.37 41.37 180 top
R403  499R2F-2-GP  [R402H16]  64.4 41.32 0 bottom
R404  100KR2J-1-GP  [R402H16]  104.07 84.53 0 top
R405  100KR2J-1-GP  [R402H16]  103.31 80.32 90 top
R406  51R2J-2-GP  [R402H16]  67.72 47.85 90 top
R407  51R2J-2-GP  [R402H16]  64.62 51.73 90 bottom
R408  51R2J-2-GP  [R402H16]  64.62 49.14 90 bottom
R409  51R2J-2-GP  [R402H16]  64.62 50.92 90 bottom
R410  0R2J-2-GP  [R402H16]  103.16 81.17 90 top
R412  49D9R2F-GP  [R402H16]  91.22 72.94 0 top
R413  49D9R2F-GP  [R402H16]  92.11 72.94 0 top
R414  49D9R2F-GP  [R402H16]  74.96 46.96 90 top
R415  49D9R2F-GP  [R402H16]  74.96 48.1 90 top
R416  51R2J-2-GP  [R402H16]  64.62 47.36 90 bottom
R417  1KR2J-1-GP  [R402H16]  64.62 48.25 90 bottom
R419  1KR2J-1-GP  [R402H16]  65.18 44.06 90 bottom
R421  51R2J-2-GP  [R402H16]  64.62 46.48 90 bottom
R422  51R2J-2-GP  [R402H16]  64.62 50.03 90 bottom
R423  51R2J-2-GP  [R402H16]  64.9 48.38 270 top
R501  121R2F-GP  [R402H16]  88.55 71.85 0 top
R502  80D6R2F-L-GP  [R402H16]  89.44 71.85 0 top
R503  100R2F-L1-GP-U  [R402H14]  89.95 73.25 90 top
R601  49D9R2F-GP  [R402H16]  70.57 50.06 270 top
R602  0R0402-PAD-2-GP  [0R0402-PAD-1]  91.85 40.99 180 top
R603  100KR2J-1-GP  [R402H16]  67.6 46.3 270 top
R604  1KR2J-1-GP  [R402H16]  68.36 39.59 180 bottom
R605  1KR2J-1-GP  [R402H16]  71.3 39.67 270 bottom
R703  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  70.8 72.03 0 top
R705  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  84.98 61.56 0 top
R709  0R0402-PAD-2-GP  [0R0402-PAD-1]  62.52 43.15 270 top
R719  100R2F-L1-GP-U  [R402H14]  72.55 64.36 90 top
R720  100R2F-L1-GP-U  [R402H14]  71.33 65.63 180 top
R721  100R2F-L1-GP-U  [R402H14]  75.34 40.1 270 top
R722  100R2F-L1-GP-U  [R402H14]  75.22 42.89 270 top
R723  54D9R2F-L1-GP  [R402H16]  65.4 46.38 270 top
R726  100R2F-L1-GP-U  [R402H14]  67.09 45.43 90 top
R727  56R2J-4-GP  [R402H16]  65.18 44.93 270 top
R728  220R2J-L2-GP  [R402H16]  65.18 43.02 270 bottom
R732  0R0402-PAD-2-GP  [0R0402-PAD-1]  64.98 47.22 270 top
R734  100R2F-L1-GP-U  [R402H14]  72.65 70.54 0 top
R735  100R2F-L1-GP-U  [R402H14]  71.84 70.54 180 top
R736  100R2J-2-GP  [R402H14]  124.86 29.12 270 top
R801  24D9R2F-L-GP  [R402H16]  74.4 55.87 270 top
R802  10KR2J-3-GP  [R402H16]  75.22 82.77 180 top
R1110  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  88.75 88.06 0 top
R1117  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  64.17 86.53 90 top
R1139  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  83.98 91.82 270 top
R1201  0R0402-PAD-2-GP  [0R0402-PAD-1]  125.51 94.96 0 top
R1202  0R0402-PAD-2-GP  [0R0402-PAD-1]  124.62 94.96 0 top
R1203  470R2F-GP  [R402H16]  128.18 45.94 270 top
R1204  0R0402-PAD-2-GP  [0R0402-PAD-1]  126.52 43.53 90 top
R1501  100R2F-L1-GP-U  [R402H14]  71.91 78.2 180 top
R1502  200R2F-L-GP  [R402H16]  90.08 85.95 0 top
R1503  10KR2J-3-GP  [R402H16]  69.09 88.74 90 bottom
R1603  113R2F-GP  [R402H16]  82.33 82.01 180 top
R1604  100R2F-L1-GP-U  [R402H14]  73.44 79.98 270 top
R1606  10KR2J-3-GP  [R402H16]  71.61 88.74 270 bottom
R1607  10KR2J-3-GP  [R402H16]  97.21 78.86 270 top
R1608  10KR2J-3-GP  [R402H16]  72.55 91.15 270 bottom
R1701  10KR2J-3-GP  [R402H16]  84.61 96.11 90 top
R1702  1KR2J-1-GP  [R402H16]  112.55 97.12 180 top
R1703  1KR2J-1-GP  [R402H16]  95.16 73.16 90 top
R1704  0R2J-2-GP  [R402H16]  99.22 71.98 0 top
R1706  0R0402-PAD-2-GP  [0R0402-PAD-1]  99.22 73.75 0 top
R1707  10KR2J-3-GP  [R402H16]  92.23 76.29 180 top
R1708  0R2J-2-GP  [R402H16]  94.9 83.79 180 top
R1709  10KR2J-3-GP  [R402H16]  163.48 37.31 270 top
R1711  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  91.19 88.11 180 top
R1713  0R0402-PAD-2-GP  [0R0402-PAD-1]  96.93 86.84 0 top
R1714  10KR2J-3-GP  [R402H16]  67.55 39.59 180 bottom
R1715  100KR2J-1-GP  [R402H16]  97.82 88.11 0 top
R1716  100KR2F-L1-GP  [R402H16]  62.51 41.77 0 top
R1717  10KR2J-3-GP  [R402H16]  66.76 81.91 180 top
R1718  0R2J-2-GP  [R402H16]  101.85 71.58 90 top
R1719  47KR2F-GP  [R402H16]  61.25 39.08 270 top
R1720  0R2J-2-GP  [R402H16]  162.08 31.81 90 top
R1722  100KR2J-1-GP  [R402H16]  62.53 40.02 0 top
R1723  10KR2J-3-GP  [R402H16]  91.35 76.29 180 top
R1724  10KR2J-3-GP  [R402H16]  96.9 73.16 270 top
R1726  10KR2J-3-GP  [R402H16]  111.41 97.12 180 top
R1727  100KR2J-1-GP  [R402H16]  108.82 98.67 90 top
R1728  0R2J-2-GP  [R402H16]  111.74 92.01 90 top
R1729  0R0402-PAD-2-GP  [0R0402-PAD-1]  110.4 90.77 0 top
R1730  330KR2J-L1-GP  [R402H16]  102.61 85.37 270 top
R1731  20KR2J-L2-GP  [R402H16]  85.63 80.49 90 top
R1732  0R0402-PAD-2-GP  [0R0402-PAD-1]  93.5 76.42 270 top
R1733  0R0402-PAD-2-GP  [0R0402-PAD-1]  56.85 87.55 90 top
R1734  0R1206-PAD-1-GP  [0R1206-PAD-1]  64.04 82.9 0 top
R1737  100KR2J-1-GP  [R402H16]  160.91 32.66 90 top
R1801  0R0402-PAD-2-GP  [0R0402-PAD-1]  95.28 76.55 270 top
R1802  1MR2J-1-GP  [R402H16]  61.63 65.5 0 bottom
R1803  2K7R2F-GP  [R402H16]  71.53 59.78 270 top
R1804  22R2J-2-GP  [R402H16]  96.43 80.74 90 top
R1805  22R2J-2-GP  [R402H16]  96.43 81.88 90 top
R1806  10R2F-L-GP  [R402H14]  135.41 100.3 0 bottom
R1807  10R2F-L-GP  [R402H14]  137.95 93.57 0 top
R1808  10R2F-L-GP  [R402H14]  131.96 100.3 0 bottom
R1809  10R2F-L-GP  [R402H14]  135.13 85.52 270 bottom
R1810  0R0402-PAD-2-GP  [0R0402-PAD-1]  61.63 67.28 0 bottom
R1811  10R2F-L-GP  [R402H14]  95.79 90.9 0 top
R1812  0R0402-PAD-2-GP  [0R0402-PAD-1]  93.76 88.36 0 top
R1813  0R0402-PAD-2-GP  [0R0402-PAD-1]  93.89 72.99 0 top
R1814  10KR2J-3-GP  [R402H16]  99.47 86.2 270 top
R1815  10MR2J-L-GP  [R402H16]  90.86 101.69 180 bottom
R1816  10KR2J-3-GP  [R402H16]  109.63 97.12 180 top
R1817  10KR2J-3-GP  [R402H16]  96.03 94.27 180 top
R1818  8K2R2F-1-GP  [R402H16]  95.57 92.98 270 top
R1819  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.19 93 90 top
R1820  10KR2J-3-GP  [R402H16]  98.7 94.27 180 top
R1821  10KR2J-3-GP  [R402H16]  99.73 90.14 270 top
R1822  1KR2J-1-GP  [R402H16]  79.92 93.57 90 top
R1823  1KR2J-1-GP  [R402H16]  80.42 92.42 90 top
R1824  1KR2J-1-GP  [R402H16]  93.99 85.87 90 top
R1825  1KR2J-1-GP  [R402H16]  94.65 88.36 180 top
R1826  1KR2J-1-GP  [R402H16]  95.54 88.36 0 top
R1827  1KR2J-1-GP  [R402H16]  95.28 86.33 0 top
R1828  0R0402-PAD-2-GP  [0R0402-PAD-1]  96.68 90.9 0 top
R1829  10KR2J-3-GP  [R402H16]  88.68 81.88 0 top
R1830  10KR2J-3-GP  [R402H16]  95.14 94.27 180 top
R1831  10KR2J-3-GP  [R402H16]  97.81 94.27 180 top
R1832  10KR2J-3-GP  [R402H16]  96.92 94.27 180 top
R1833  10KR2J-3-GP  [R402H16]  90.96 82.14 0 top
R1834  1KR2J-1-GP  [R402H16]  134.25 86.79 0 bottom
R1835  1KR2J-1-GP  [R402H16]  119.29 105.89 0 top
R1836  2K2R2J-2-GP  [R402H16]  77.76 92.8 270 top
R1837  150KR2J-GP  [R402H16]  77.76 93.69 270 top
R1901  200R2F-L-GP  [R402H16]  80.91 82.44 90 top
R1902  10KR2J-3-GP  [R402H16]  97.59 79.67 270 top
R1907  33R2J-2-GP  [R402H16]  97.57 68.55 270 top
R1908  0R0402-PAD-2-GP  [0R0402-PAD-1]  97.92 70.63 270 top
R1909  1KR2J-1-GP  [R402H16]  97.57 66.77 270 top
R1911  0R0402-PAD-2-GP  [0R0402-PAD-1]  97.57 69.44 270 top
R1912  33R2J-2-GP  [R402H16]  97.57 67.66 270 top
R2006  1KR2J-1-GP  [R402H16]  89.57 81.88 0 top
R2007  1KR2J-1-GP  [R402H16]  91.85 85.06 0 top
R2019  1KR2J-1-GP  [R402H16]  91.35 83.41 90 top
R2020  0R2J-2-GP  [R402H16]  76.11 88.23 180 top
R2021  0R2J-2-GP  [R402H16]  74.58 89.63 90 top
R2022  10KR2J-3-GP  [R402H16]  95.03 104.11 270 bottom
R2039  10KR2J-3-GP  [R402H16]  97.7 85.57 270 top
R2040  10KR2J-3-GP  [R402H16]  78.52 97 270 top
R2041  10KR2J-3-GP  [R402H16]  84.49 87.72 270 top
R2042  10KR2J-3-GP  [R402H16]  81.6 88.61 0 top
R2043  10KR2J-3-GP  [R402H16]  85.88 86.84 0 top
R2044  10KR2J-3-GP  [R402H16]  79.94 89.88 0 top
R2046  51KR2J-1-GP  [R402H16]  81.21 89.88 90 top
R2048  51KR2J-1-GP  [R402H16]  84.49 88.61 270 top
R2049  51KR2J-1-GP  [R402H16]  84.49 89.5 270 top
R2101  0R2J-2-GP  [R402H16]  83.34 96.54 180 top
R2102  0R0402-PAD-2-GP  [0R0402-PAD-1]  84.61 97 270 top
R2106  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  102.45 84.31 270 top
R2107  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  75.09 75.91 180 top
R2108  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  78.39 83.41 0 top
R2109  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  77.02 69.56 0 top
R2110  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  79.56 69.56 0 top
R2111  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  78.29 69.56 0 top
R2401  0R0402-PAD-2-GP  [0R0402-PAD-1]  163.59 40.3 0 top
R2402  0R0402-PAD-2-GP  [0R0402-PAD-1]  142.27 37.81 90 top
R2403  49D9R2F-GP  [R402H16]  128.48 25.14 270 top
R2404  10R2F-L-GP  [R402H14]  133.76 98.01 90 top
R2405  10R2F-L-GP  [R402H14]  132.8 100.3 180 bottom
R2406  10R2F-L-GP  [R402H14]  139.38 83.64 0 top
R2409  100KR2J-1-GP  [R402H16]  153.19 58.39 180 top
R2410  0R0402-PAD-2-GP  [0R0402-PAD-1]  148.75 58.39 180 top
R2411  0R0402-PAD-2-GP  [0R0402-PAD-1]  144.3 57.75 180 top
R2412  0R0402-PAD-2-GP  [0R0402-PAD-1]  163.63 43.73 0 top
R2414  4K7R2J-2-GP  [R402H16]  117.74 21.23 180 top
R2415  10KR2J-3-GP  [R402H16]  141.76 35.02 0 top
R2416  0R0402-PAD-2-GP  [0R0402-PAD-1]  142.53 32.48 270 bottom
R2417  100KR2J-1-GP  [R402H16]  140.75 35.91 0 bottom
R2418  0R2J-2-GP  [R402H16]  140.88 34 180 bottom
R2419  0R0402-PAD-2-GP  [0R0402-PAD-1]  164.24 55.57 90 top
R2420  10KR2J-3-GP  [R402H16]  128.56 23.84 0 top
R2421  330R2J-3-GP  [R402H16]  145.57 35.78 180 top
R2422  330R2J-3-GP  [R402H16]  148.75 33.47 90 top
R2423  330R2J-3-GP  [R402H16]  151.04 36.15 180 top
R2424  20KR2F-L-GP  [R402H16]  164.22 53.03 270 top
R2425  10KR2J-3-GP  [R402H16]  138.49 22.68 90 top
R2427  10KR2J-3-GP  [R402H16]  162.75 40.3 0 top
R2429  10KR2J-3-GP  [R402H16]  138.08 76.17 270 top
R2430  10KR2J-3-GP  [R402H16]  157.39 58.39 180 top
R2431  0R0402-PAD-2-GP  [0R0402-PAD-1]  160.69 58.51 0 top
R2432  1KR2J-1-GP  [R402H16]  159.63 34.64 180 top
R2433  100KR2J-1-GP  [R402H16]  142.65 73.63 0 top
R2434  100KR2J-1-GP  [R402H16]  163.63 45.41 180 top
R2435  0R0402-PAD-2-GP  [0R0402-PAD-1]  140.75 43.1 90 top
R2436  100KR2J-1-GP  [R402H16]  140.7 42.26 270 top
R2437  43R2J-GP  [R402H16]  140.37 40.99 0 top
R2438  10KR2J-3-GP  [R402H16]  137.5 23.54 270 top
R2439  10KR2J-3-GP  [R402H16]  131.22 23.84 0 top
R2440  0R2J-2-GP  [R402H16]  64.04 39.46 180 bottom
R2441  10KR2J-3-GP  [R402H16]  131.86 25.24 90 top
R2442  10KR2J-3-GP  [R402H16]  135.49 26.28 270 top
R2443  64K9R2F-1-GP  [R402H16]  148.37 34.77 180 top
R2444  100KR2F-L1-GP  [R402H16]  146.16 33.75 270 top
R2445  0R0402-PAD-2-GP  [0R0402-PAD-1]  143.3 32.92 90 top
R2446  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  143.54 61.31 0 top
R2447  0R2J-2-GP  [R402H16]  145.41 65.29 0 top
R2448  10KR2F-2-GP  [R402H16]  164.67 54.3 180 top
R2449  100KR2J-1-GP  [R402H16]  142.53 57.75 0 top
R2450  100KR2J-1-GP  [R402H16]  143.42 57.75 180 top
R2451  100KR2J-1-GP  [R402H16]  159.16 35.91 270 top
R2452  100KR2J-1-GP  [R402H16]  14.38 53.94 180 bottom
R2453  10KR2J-3-GP  [R402H16]  135.97 25.04 0 top
R2454  100KR2J-1-GP  [R402H16]  157.51 35.02 90 top
R2455  100KR2J-1-GP  [R402H16]  164.22 52.19 270 top
R2456  10KR2J-3-GP  [R402H16]  163.16 41.54 90 top
R2457  0R2J-2-GP  [R402H16]  162.8 43.73 0 top
R2458  0R0402-PAD-2-GP  [0R0402-PAD-1]  150.19 34.3 270 bottom
R2459  0R2J-2-GP  [R402H16]  146.23 65.28 0 top
R2460  10KR2J-3-GP  [R402H16]  163.76 49.19 90 top
R2461  100KR2J-1-GP  [R402H16]  127.03 29.81 270 top
R2462  0R0402-PAD-2-GP  [0R0402-PAD-1]  151.8 57.88 90 top
R2463  1KR2J-1-GP  [R402H16]  158.02 32.61 270 top
R2464  0R0402-PAD-2-GP  [0R0402-PAD-1]  120.56 22.19 180 top
R2465  0R0402-PAD-2-GP  [0R0402-PAD-1]  129.5 23.87 0 top
R2466  0R0402-PAD-2-GP  [0R0402-PAD-1]  121.44 22.19 0 top
R2467  0R0402-PAD-2-GP  [0R0402-PAD-1]  135.13 25.04 180 top
R2468  0R2J-2-GP  [R402H16]  139.86 23.11 0 top
R2469  0R0402-PAD-2-GP  [0R0402-PAD-1]  162.21 36.92 180 top
R2470  0R0402-PAD-2-GP  [0R0402-PAD-1]  163.76 48.35 270 top
R2471  0R2J-2-GP  [R402H16]  140.24 28.03 0 top
R2472  0R0402-PAD-2-GP  [0R0402-PAD-1]  158.78 34.64 0 top
R2473  10KR2J-3-GP  [R402H16]  156.21 36.4 0 top
R2474  0R0402-PAD-2-GP  [0R0402-PAD-1]  130.33 23.84 180 top
R2475  0R2J-2-GP  [R402H16]  133.18 25.75 0 top
R2476  0R2J-2-GP  [R402H16]  134.02 25.75 0 top
R2477  0R2J-2-GP  [R402H16]  126.52 28.54 180 top
R2478  0R0402-PAD-2-GP  [0R0402-PAD-1]  122.33 22.19 180 top
R2479  0R0402-PAD-2-GP  [0R0402-PAD-1]  162.8 45.41 180 top
R2480  100KR2J-1-GP  [R402H16]  118.73 22.19 0 top
R2481  0R0402-PAD-2-GP  [0R0402-PAD-1]  154.08 58.39 0 top
R2482  0R0402-PAD-2-GP  [0R0402-PAD-1]  119.56 22.19 180 top
R2483  0R0402-PAD-2-GP  [0R0402-PAD-1]  119.41 20.16 270 top
R2484  100KR2J-1-GP  [R402H16]  163.48 38.19 90 top
R2485  0R0402-PAD-2-GP  [0R0402-PAD-1]  161.7 58.51 0 top
R2486  0R0402-PAD-2-GP  [0R0402-PAD-1]  163.47 58.51 0 top
R2487  0R0402-PAD-2-GP  [0R0402-PAD-1]  162.59 58.51 0 top
R2488  100KR2J-1-GP  [R402H16]  132.62 35.81 180 bottom
R2489  100KR2J-1-GP  [R402H16]  150.39 26.12 270 bottom
R2490  0R0402-PAD-2-GP  [0R0402-PAD-1]  117.51 105.38 90 top
R2491  0R2J-2-GP  [R402H16]  140.81 84.11 0 top
R2492  0R2J-2-GP  [R402H16]  142.27 38.7 90 top
R2493  0R2J-2-GP  [R402H16]  149.72 35.46 270 bottom
R2494  0R2J-2-GP  [R402H16]  147.35 35.91 0 top
R2495  100KR2J-1-GP  [R402H16]  143.08 50.82 0 top
R2496  100KR2J-1-GP  [R402H16]  159.16 36.8 270 top
R2497  0R0402-PAD-2-GP  [0R0402-PAD-1]  150.16 33.91 0 top
R2498  10KR2J-3-GP  [R402H16]  141.91 49.13 180 bottom
R2499  10KR2J-3-GP  [R402H16]  163.76 50.03 90 top
R2501  4K7R2J-2-GP  [R402H16]  115.86 106.27 180 top
R2502  4K7R2J-2-GP  [R402H16]  139.35 87.22 270 bottom
R2503  10R2F-L-GP  [R402H14]  122.59 107.16 270 top
R2504  10MR2J-L-GP  [R402H16]  140.29 62.22 0 top
R2505  10R2F-L-GP  [R402H14]  132.49 99.28 0 top
R2506  10R2F-L-GP  [R402H14]  130.36 100.93 90 top
R2507  10R2F-L-GP  [R402H14]  130.12 101.88 270 top
R2508  10R2F-L-GP  [R402H14]  130.84 99.79 270 top
R2509  10R2F-L-GP  [R402H14]  122.59 106.27 270 top
R2510  10KR2F-2-GP  [R402H16]  145.45 62.58 270 top
R2511  10R2F-L-GP  [R402H14]  133.38 99.28 0 top
R2512  10R2F-L-GP  [R402H14]  133.64 100.3 0 bottom
R2513  10R2F-L-GP  [R402H14]  137.19 86.84 0 bottom
R2514  10R2F-L-GP  [R402H14]  135.52 86.79 0 bottom
R2515  0R0402-PAD-2-GP  [0R0402-PAD-1]  131.4 104.58 90 top
R2516  0R0402-PAD-2-GP  [0R0402-PAD-1]  138.08 98.77 0 top
R2601  0R2J-2-GP  [R402H16]  101.38 31.21 180 bottom
R2602  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.87 29.43 90 bottom
R2603  7K5R2F-1-GP  [R402H16]  66.38 38.7 180 top
R2604  7K5R2F-1-GP  [R402H16]  72.8 35.78 180 top
R2607  10KR2J-3-GP  [R402H16]  100.87 28.54 90 bottom
R2608  25K5R2F-GP  [R402H16]  78.14 36.16 180 top
R2609  10R2F-L-GP  [R402H14]  76.36 35.91 180 top
R2610  NTC-100K-8-GP  [NTC-603H38]  74.58 36.8 90 top
R2611  0R0402-PAD-2-GP  [0R0402-PAD-1]  80.42 36.42 180 top
R2612  0R0402-PAD-2-GP  [0R0402-PAD-1]  137.45 69.06 270 bottom
R2613  0R0402-PAD-2-GP  [0R0402-PAD-1]  157.28 60.83 180 top
R2614  0R0402-PAD-2-GP  [0R0402-PAD-1]  155.71 58.39 180 top
R2615  0R2J-2-GP  [R402H16]  95.79 29.18 180 bottom
R2701  10KR2J-3-GP  [R402H16]  26.5 24.48 270 top
R2704  10KR2J-3-GP  [R402H16]  30.13 29.69 90 top
R2706  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  19.97 23.92 270 bottom
R2713  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  32.77 24.99 0 top
R2714  0R0402-PAD-2-GP  [0R0402-PAD-1]  30 24.61 0 top
R2715  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  31.02 27.02 180 top
R2716  33R2J-2-GP  [R402H16]  27.97 28.29 90 top
R2717  1KR2J-1-GP  [R402H16]  22.26 17.62 90 top
R2718  33R2J-2-GP  [R402H16]  27.72 19.53 180 top
R2719  0R0402-PAD-2-GP  [0R0402-PAD-1]  27.97 20.92 270 top
R2720  0R0402-PAD-2-GP  [0R0402-PAD-1]  26.83 19.53 180 top
R2721  1KR2J-1-GP  [R402H16]  22.26 16.73 270 top
R2722  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  26.7 34.51 270 top
R2723  100KR2J-1-GP  [R402H16]  27.97 29.18 270 top
R2725  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  24.16 33.88 270 top
R2726  0R3J-0-U-GP  [R603H22]  25.43 35.78 270 top
R2727  0R3J-0-U-GP  [R603H22]  31.15 24.35 0 top
R2901  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.03 15.84 90 bottom
R2902  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.03 14.57 90 bottom
R2903  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  15.91 6.83 270 top
R2904  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  15.91 8.1 270 top
R2905  100R2F-L1-GP-U  [R402H14]  17.99 21.47 180 bottom
R2906  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  15.53 21.81 180 bottom
R2907  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  19.72 18.13 90 bottom
R2908  10R2F-L-GP  [R402H14]  15.78 28.03 90 bottom
R2909  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.44 34.25 0 bottom
R2910  10R2F-L-GP  [R402H14]  15.78 27.15 90 bottom
R2911  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  17.41 34.77 90 top
R2912  100R2F-L1-GP-U  [R402H14]  16.67 20.8 0 top
R2913  100R2F-L1-GP-U  [R402H14]  19.87 19.53 0 top
R2915  470KR2J-2-GP  [R402H16]  25.31 36.29 180 bottom
R2916  4K99R2F-L-GP  [R402H16]  17.66 32.1 0 bottom
R2917  0R3J-0-U-GP  [R603H22]  28.61 27.02 0 bottom
R2918  100KR2J-1-GP  [R402H16]  31.66 20.8 270 top
R2919  10KR2J-3-GP  [R402H16]  19.87 19.7 0 bottom
R2920  10KR2J-3-GP  [R402H16]  15.4 31.97 180 bottom
R2921  2K2R2J-2-GP  [R402H16]  17.02 22.32 270 top
R2922  100R2F-L1-GP-U  [R402H14]  15.91 23.34 270 top
R2924  13KR2F-GP  [R402H16]  17.51 34.26 180 bottom
R3401  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.41 53.94 270 bottom
R3402  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 55.85 270 bottom
R3403  20KR2F-L-GP  [R402H16]  25.18 54.32 0 top
R3404  22K1R2F-L-GP  [R402H16]  24.8 53.05 90 top
R3405  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 53.05 270 bottom
R3406  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 54.96 270 bottom
R3501  100KR2J-1-GP  [R402H16]  18.57 47.85 180 bottom
R3605  0R0402-PAD-2-GP  [0R0402-PAD-1]  18.45 63.47 90 bottom
R3606  0R0402-PAD-2-GP  [0R0402-PAD-1]  18.45 64.48 90 bottom
R3609  0R0402-PAD-2-GP  [0R0402-PAD-1]  18.45 61.31 90 bottom
R3610  0R0402-PAD-2-GP  [0R0402-PAD-1]  18.45 62.32 90 bottom
R3611  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 45.43 90 bottom
R3612  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 43.27 90 bottom
R3613  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 44.29 90 bottom
R3614  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.34 46.45 90 bottom
R4002  0R0402-PAD-2-GP  [0R0402-PAD-1]  52.64 90.03 270 bottom
R4005  1KR2J-1-GP  [R402H16]  52.63 89.2 90 bottom
R4006  20KR2F-L-GP  [R402H16]  136.07 31.03 90 bottom
R4009  10KR2J-3-GP  [R402H16]  137.42 36.75 0 bottom
R4010  0R0402-PAD-2-GP  [0R0402-PAD-1]  40.67 91.28 270 top
R4011  0R0402-PAD-2-GP  [0R0402-PAD-1]  52.37 90.85 90 bottom
R4017  0R0402-PAD-2-GP  [0R0402-PAD-1]  40.67 90.39 270 top
R4023  0R0402-PAD-2-GP  [0R0402-PAD-1]  61.5 75.91 90 bottom
R4024  0R0402-PAD-2-GP  [0R0402-PAD-1]  62.85 78.15 0 bottom
R4026  10KR2J-3-GP  [R402H16]  62.77 76.42 0 bottom
R4029  0R0402-PAD-2-GP  [0R0402-PAD-1]  44.66 91.97 0 bottom
R4030  0R0402-PAD-2-GP  [0R0402-PAD-1]  52.37 91.67 90 bottom
R4031  100KR2J-1-GP  [R402H16]  45.5 91.66 0 bottom
R4032  100KR2J-1-GP  [R402H16]  50.91 92.49 90 bottom
R4033  0R2J-2-GP  [R402H16]  46.39 91.66 0 bottom
R4036  0R0402-PAD-2-GP  [0R0402-PAD-1]  68.03 73.2 270 top
R4038  0R0402-PAD-2-GP  [0R0402-PAD-1]  74.61 72 0 top
R4041  20KR2J-L2-GP  [R402H16]  19.59 34.64 180 bottom
R4042  0R0402-PAD-2-GP  [0R0402-PAD-1]  67.47 90.32 0 top
R4044  10KR2J-3-GP  [R402H16]  20.48 34.64 0 bottom
R4101  0R5J-5-GP  [R805H24]  71.41 112.04 270 top
R4102  0R0402-PAD-2-GP  [0R0402-PAD-1]  77.5 112.49 270 top
R4103  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  75.98 104.54 90 top
R4201  1K8R2F-GP  [R402H16]  125.76 36.16 0 top
R4202  2R2F-GP  [R402H16]  121.7 33.75 180 top
R4203  1K8R2F-GP  [R402H16]  137.45 66.77 0 bottom
R4204  0R2J-2-GP  [R402H16]  136.56 66.77 180 bottom
R4206  1K8R2F-GP  [R402H16]  136.56 64.99 0 bottom
R4207  24D9R2F-L-GP  [R402H16]  138.72 67.68 0 bottom
R4208  2R2F-GP  [R402H16]  137.4 64.99 180 bottom
R4209  1K8R2F-GP  [R402H16]  124.87 35.53 180 top
R4210  0R2J-2-GP  [R402H16]  122.59 33.62 180 top
R4211  24D9R2F-L-GP  [R402H16]  121.06 36.04 180 top
R4301  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.33 25.06 0 bottom
R5411  4K7R2J-2-GP  [R402H16]  15.22 75 0 bottom
R5412  4K7R2J-2-GP  [R402H16]  14.38 75.02 0 bottom
R5413  4K7R2J-2-GP  [R402H16]  16.24 84.4 90 bottom
R5414  4K7R2J-2-GP  [R402H16]  15.2 82.19 180 top
R5415  4K7R2J-2-GP  [R402H16]  16.16 75.02 0 bottom
R5416  4K7R2J-2-GP  [R402H16]  16.8 77.92 0 top
R5417  4K7R2J-2-GP  [R402H16]  17.05 75.02 0 bottom
R5418  4K7R2J-2-GP  [R402H16]  17.94 75.02 0 bottom
R5419  4K7R2J-2-GP  [R402H16]  18.83 75.02 0 bottom
R5420  4K7R2J-2-GP  [R402H16]  16.31 84.37 270 top
R5501  0R0402-PAD-2-GP  [0R0402-PAD-1]  53.88 94.71 270 top
R5502  0R2J-2-GP  [R402H16]  71.03 97.76 180 top
R5503  0R0402-PAD-2-GP  [0R0402-PAD-1]  56.04 90.65 180 bottom
R5504  33R2J-2-GP  [R402H16]  56.29 99.28 180 top
R5505  33R2J-2-GP  [R402H16]  55.4 99.28 180 top
R5506  100R2J-2-GP  [R402H14]  53.75 97.88 90 top
R5507  0R3J-6-GP  [R603H22]  26.58 95.34 90 top
R5510  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  30.13 102.46 90 top
R5511  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  30.13 101.19 90 top
R5513  0R3J-6-GP  [R603H22]  38.77 92.3 270 bottom
R5514  0R6J-L-GP  [R1206H26]  61.88 101.42 270 top
R5515  0R3J-6-GP  [R603H22]  31.91 92.75 90 bottom
R5516  0R0402-PAD-2-GP  [0R0402-PAD-1]  41.13 94.72 90 top
R5517  1KR2J-1-GP  [R402H16]  41.74 96.87 0 top
R5518  10KR2F-2-GP  [R402H16]  42.18 95.58 270 top
R5701  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  18.32 72.99 270 top
R5702  150R2J-L1-GP-U  [R402H16]  11.84 79.52 0 bottom
R5703  150R2J-L1-GP-U  [R402H16]  11.77 84.37 0 bottom
R5704  150R2J-L1-GP-U  [R402H16]  11.74 81.22 0 bottom
R5705  150R2J-L1-GP-U  [R402H16]  11.84 77.21 0 bottom
R5706  2K2R2J-2-GP  [R402H16]  14.31 86.71 0 top
R5707  2K2R2J-2-GP  [R402H16]  14.31 88.44 0 top
R5710  4K3R2J-GP  [R402H16]  15.5 77.72 90 top
R5715  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  21.93 91.15 270 top
R5716  0R3J-0-U-GP  [R603H22]  21.62 92.55 270 top
R5721  10KR2J-3-GP  [R402H16]  16.03 64.61 0 top
R5722  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.79 68.34 270 bottom
R5723  0R0402-PAD-2-GP  [0R0402-PAD-1]  16.03 62.83 180 top
R6001  0R0402-PAD-2-GP  [0R0402-PAD-1]  137.93 29.76 0 bottom
R6002  0R0402-PAD-2-GP  [0R0402-PAD-1]  129.95 29.18 270 bottom
R6501  0R3J-0-U-GP  [R603H22]  26.19 15.08 180 bottom
R6502  0R3J-0-U-GP  [R603H22]  104.86 26.22 180 bottom
R6503  100R3J-4-GP  [R603H22]  116.57 19.73 90 top
R6504  20KR2F-L-GP  [R402H16]  99.6 22.95 270 bottom
R6505  0R2J-2-GP  [R402H16]  120.94 24.48 270 top
R6506  0R2J-2-GP  [R402H16]  120.17 26.26 270 top
R6509  100KR2J-1-GP  [R402H16]  18.83 11.02 0 top
R6510  0R0402-PAD-2-GP  [0R0402-PAD-1]  124.87 23.46 270 top
R6511  10KR2J-3-GP  [R402H16]  112.55 26.76 0 top
R6512  0R0402-PAD-2-GP  [0R0402-PAD-1]  147.35 29.86 90 bottom
R6513  1KR2J-1-GP  [R402H16]  147.35 28.09 270 bottom
R6514  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  105.04 23.84 180 bottom
R6605  0R0402-PAD-2-GP  [0R0402-PAD-1]  150.93 61.56 180 top
R6606  0R0402-PAD-2-GP  [0R0402-PAD-1]  150.12 61.56 180 top
R6801  0R2J-2-GP  [R402H16]  104.55 110.46 90 top
R6802  0R2J-2-GP  [R402H16]  106.84 110.48 90 top
R6901  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  82.46 110.46 90 top
R6902  100KR2J-1-GP  [R402H16]  95.92 107.66 180 top
R6904  1K5R2F-2-GP  [R402H16]  90.84 103.73 0 bottom
R6905  0R0402-PAD-2-GP  [0R0402-PAD-1]  83.85 105 90 top
R6906  0R0402-PAD-2-GP  [0R0402-PAD-1]  83.85 104.11 90 top
R6907  20KR2J-L2-GP  [R402H16]  91.09 99.03 90 top
R6908  10KR2J-3-GP  [R402H16]  85.76 112.31 90 top
R6909  10KR2J-3-GP  [R402H16]  88.42 112.36 90 top
R6910  10KR2J-3-GP  [R402H16]  90.58 111.85 0 top
R6911  10KR2J-3-GP  [R402H16]  89.69 111.85 180 top
R6912  10KR2J-3-GP  [R402H16]  91.47 111.85 0 top
R6913  10KR2J-3-GP  [R402H16]  92.36 111.85 180 top
R6914  10KR2J-3-GP  [R402H16]  94.14 111.85 0 top
R6915  10KR2J-3-GP  [R402H16]  93.25 111.85 180 top
R6916  10KR2J-3-GP  [R402H16]  95.03 111.85 0 top
R6917  10KR2J-3-GP  [R402H16]  95.92 111.85 180 top
R6918  10KR2J-3-GP  [R402H16]  95.54 109.57 180 top
R6919  10KR2J-3-GP  [R402H16]  96.81 111.85 180 top

# Allegro board 14296-1.0727WZS1940.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
1D0V_S5 on L2VCC: 77.96,69.25 77.06,70.15 77.06,73.07 74.66,75.47 71.87,75.47 70.45,76.88 70.45,83.3 71.22,84.06 71.22,90.65 70.7,91.17 69.31,91.17 69.31,92.09 69.96,92.74 72.09,92.74 73.55,91.38 73.55,86.16 72.91,85.28 72.87,85.24 72.87,85.22 72.86,85.21 72.87,85.14 72.87,81.71 72.23,81.07 72.23,79.52 72.6,79.15 73.61,79.15 74.01,78.76 74.01,78.12 76.15,75.98 77.55,75.98 79.71,73.82 83.27,73.82 84.04,73.04 84.04,69.26 84.03,69.25
1D0V_S5 on L4: 75.85,88.36 77.31,86.9 77.31,83.41 78.9,81.82 78.9,76.04 79.41,75.53 79.41,74.39 80.04,73.75 80.04,71.85 80.17,71.72 82.46,71.72 82.58,71.85 82.58,72.1 82.84,72.36 83.22,72.36 83.34,72.23 83.34,71.21 83.22,71.09 80.17,71.09 79.92,71.34 79.41,71.34 79.28,71.21 79.28,70.96 79.15,70.83 78.77,70.83 78.65,70.96 78.65,71.21 78.52,71.34 77.76,71.34 77.5,71.6 77.5,72.1 77.12,72.48 77.12,73.12 74.84,75.41 74.84,81.37 73.57,82.64 73.57,87.9 70.54,90.93 69.76,90.93 69.5,91.18 69.5,92.3 70.39,93.19 73.06,93.19 73.57,92.68 74.71,92.68 75.85,91.53
1D0V_S5 on L6: 70.11,89.76 71.66,89.76 72.8,90.9 74.33,90.9 76.61,93.19 80.04,93.19 80.42,92.8 86.65,92.8 87.66,93.82 87.66,94.71 89.06,96.11 92.74,96.11 93,95.85 94.27,95.85 94.65,96.23 94.65,96.87 94.14,97.38 88.3,97.38 88.29,97.37 87.65,97.37 84.96,94.68 75.7,94.68 74.77,93.75 72.58,93.75 71.77,94.56 69.68,94.56 67.98,92.86 67.19,92.86 66.81,93.24 63.1,93.24 62.85,92.98 62.85,90.39 63.17,90.07 63.17,89.19 62.27,88.3 62.27,88.28 62.06,88.07 62.06,86.8 62.67,86.19 65.55,86.19 67.57,88.21 68.56,88.21
1D5V_S0 on TOP: 18.7,72.48 18.57,72.61 18.57,73.63 18.7,73.75 19.97,73.75 20.23,73.5 20.23,72.74 20.1,72.61 19.72,72.61 19.59,72.48
1D5V_VDD on TOP: 16.8,72.36 14.13,75.02 13.11,75.02 12.35,75.79 12.35,76.42 13.06,77.13 13.06,85.01 13.32,85.26 14.51,85.26 14.61,85.16 14.61,84.75 14.18,84.32 14.18,83.53 14.64,83.08 14.64,76.42 15.27,75.79 16.67,75.79 16.85,75.96 16.85,76.96 16.97,77.08 17.18,77.08 17.33,77.23 17.33,77.74 17.41,77.82 17.99,77.82 18.04,77.77 18.04,75.38 17.56,74.9 17.56,73.88 18.07,73.37 18.07,72.48 17.94,72.36 ; 1 cut-out
1D5V_VDD on BOTTOM: 12.22,75.15 12.1,75.28 12.1,75.76 13.72,77.39 13.72,78.05 13.88,78.2 14.48,78.2 14.51,78.17 14.51,76.29 14,75.79 14,75.41 13.75,75.15 ; 1 cut-out
1D35V_S3 on TOP: outline of 100 points within 83.47,35.91 134.27,74.77 ; 85 cut-outs
1D35V_S3 on BOTTOM: 133.76,50.77 133.13,51.4 133.13,57.6 133.26,57.73 133.26,58.51 133,58.77 131.35,58.77 131.1,59.02 131.1,73.88 131.22,74.01 131.99,74.01 132.11,73.88 132.11,73.5 132.62,72.99 134.65,72.99 135.16,73.5 135.16,75.79 135.92,75.79 135.92,72.36 135.54,71.98 131.99,71.98 131.99,64.1 132.11,63.98 135.54,63.98 136.68,62.83 138.46,62.83 138.72,62.58 138.72,59.02 138.84,58.9 138.84,58.01 138.97,57.88 138.97,57.12 139.1,56.99 139.61,56.99 139.73,56.86 139.73,53.43 140.37,52.8 140.37,51.53 139.61,50.77 ; 3 cut-outs
3D3V_CAMERA_S0 on BOTTOM: 39.15,91.15 39.02,91.28 39.02,92.93 40.29,94.2 42.32,94.2 42.83,94.71 44.23,94.71 44.23,92.37 43.72,91.87 43.16,91.87 43.09,91.79 40.67,91.79 40.04,91.15 ; 5 cut-outs
3D3V_S0 on TOP: 151.78,65.22 150.64,66.36 150.64,66.78 150.79,66.93 151.44,66.93 152.61,65.75 152.61,65.3 152.53,65.22
3D3V_S0 on TOP: 75.85,82.52 75.6,82.77 75.09,82.77 75.09,82.9 74.33,83.66 73.31,83.66 73.18,83.79 73.18,85.18 72.8,85.57 72.8,87.47 72.55,87.72 72.55,89.88 72.68,90.01 72.93,90.01 73.06,89.88 73.06,89.5 73.18,89.38 73.44,89.38 73.82,88.99 73.82,87.09 74.07,86.84 74.07,85.18 75.22,84.04 76.99,84.04 77.38,83.66 77.38,82.64 77.25,82.52 ; 1 cut-out
3D3V_S0 on TOP: 62.64,34.89 62.39,35.15 62.39,36.42 63.02,37.05 64.93,37.05 65.11,36.87 65.11,36.49 65.41,36.19 65.95,36.19 66.15,36.39 66.15,37.38 66.07,37.46 66.07,38.5 66.15,38.58 66.61,38.58 66.73,38.45 66.73,38.04 67.04,37.74 67.93,37.74 68.15,37.97 68.71,37.97 68.82,37.86 68.82,35.68 68.21,35.07 63.71,35.07 63.53,34.89 ; 3 cut-outs
3D3V_S0 on TOP: 30.64,24.61 30.51,24.73 30.51,26.64 30.64,26.76 31.4,26.76 31.81,27.17 32.8,27.17 32.87,27.1 32.87,26.28 32.82,26.23 31.88,26.23 31.53,25.88 31.53,25.37 31.66,25.24 31.66,24.73 31.53,24.61
3D3V_S0 on TOP: 81.82,91.15 81.57,91.41 81.57,93.06 80.42,94.2 80.42,98.65 78.14,100.93 77.5,100.93 77.38,101.06 77.38,101.57 77.5,101.69 78.39,101.69 81.31,98.77 81.31,94.71 82.58,93.44 82.58,91.41 82.33,91.15
3D3V_S0 on TOP: 31.02,91.92 31.02,92.93 31.12,93.03 31.37,93.03 33.33,94.99 34.28,94.99 34.99,94.28 37.56,94.28 37.87,93.96 40.11,93.96 40.41,94.27 41.8,94.27 42.17,94.63 42.17,97.61 42.05,97.73 41.1,97.73 40.8,97.42 40.24,97.42 40.12,97.53 40.12,98.45 40.29,98.62 41.88,98.62 42.26,99 42.26,102.32 42.78,102.84 51.21,102.84 51.47,102.58 51.47,98.39 51.34,98.27 49.82,98.27 49.69,98.39 49.69,101.31 49.56,101.44 44.41,101.44 43.67,100.71 43.67,99.08 43.82,98.94 43.82,95.57 44.82,94.57 44.82,93.82 42.91,91.92 ; 4 cut-outs
3D3V_S0 on BOTTOM: 103.54,26.51 103.28,26.76 103.28,27.78 103.54,28.03 105.06,28.03 105.57,27.53 105.57,26.64 105.44,26.51 ; 1 cut-out
3D3V_S0 on BOTTOM: 145.14,61.22 144.61,61.75 144.61,62.41 144.44,62.58 143.29,62.58 143.16,62.71 143.16,64.36 144.56,64.36 145.07,64.86 145.7,64.86 147.73,66.9 152.05,66.9 152.43,66.52 152.43,64.99 151.92,64.48 149.26,64.48 148.75,63.98 148.75,63.34 146.63,61.22
3D3V_S0 on BOTTOM: 32.04,90.26 31.91,90.39 31.91,94.33 32.54,94.96 36.86,94.96 38.01,93.82 38.39,93.82 38.64,93.57 38.64,91.41 38.39,91.15 37.37,91.15 36.61,91.92 33.69,91.92 33.18,91.41 33.18,90.52 32.93,90.26 ; 8 cut-outs
3D3V_S0 on BOTTOM: 98.58,109.82 98.46,109.95 98.46,111.6 98.08,111.98 98.08,113.12 98.46,113.51 99.73,113.51 100.11,113.12 100.11,112.11 99.85,111.85 99.6,111.85 99.35,111.6 99.35,109.95 99.22,109.82
3D3V_S0 on L3: 38.59,35.35 38.51,35.27 36.48,35.27 31.66,40.1 31.66,45.31 31.78,45.43 31.78,46.71 29.24,49.25 29.24,56.99 29.37,57.12 29.37,60.29 27.21,62.45 27.21,63.21 27.59,63.59 29.37,63.59 31.24,61.72 31.24,58.42 32.27,57.39 32.27,53.32 31.91,52.95 31.91,49.37 33.94,47.34 33.94,43.02 33.31,42.39 33.31,40.86 35.08,39.08 37.37,39.08 38.59,37.86
3D3V_S0 on L4: 45.5,39.21 48.29,36.42 62.9,36.42 63.79,35.53 63.79,35.15 63.53,34.89 47.53,34.89 44.48,37.94 39.4,37.94 39.4,37.94 39.03,37.94 38.52,37.43 38.52,36.82 38.42,36.72 37.71,36.72 37.62,36.81 37.62,38.45 38.39,39.21
3D3V_S0 on L6: 72.55,90.01 72.93,90.01 73.06,89.88 73.06,89.63 73.31,89.38 74.07,89.38 75.09,90.39 76.36,90.39 76.87,90.9 80.8,90.9 81.69,91.79 82.46,91.79 82.71,91.53 84.87,91.53 87.28,89.12 90.33,89.12 90.46,88.99 90.46,88.61 90.33,88.49 88.4,88.49 88.17,88.26 87.13,88.26 84.87,90.52 82.58,90.52 82.2,90.9 81.82,90.9 81.19,90.26 77.25,90.26 76.74,89.76 75.6,89.76 74.58,88.74 72.8,88.74 72.42,89.12 72.42,89.88
3D3V_S0 on L6: 19.84,74.64 21.24,74.64 22.38,73.5 22.38,67.4 26.58,63.21 27.59,63.21 27.97,62.83 27.97,62.45 27.59,62.07 25.94,62.07 21.11,66.9 21.11,73.25 20.73,73.63 19.84,73.63 19.59,73.88 19.59,74.39
3D3V_S0 on L6: outline of 120 points within 33.24,65.25 154.27,113
3D3V_S5 on TOP: 141.89,61.56 141.76,61.69 141.76,62.07 142.15,62.45 142.15,62.96 142.27,63.09 142.27,65.88 142.4,66.01 142.91,66.01 142.91,66 143.45,66 144.14,65.3 144.14,63.29 144.43,63 144.43,61.94 144.05,61.56 ; 4 cut-outs
3D3V_S5 on TOP: 32.42,81.63 31.91,82.14 31.91,87.6 31.02,88.49 31.02,90.65 36.23,90.65 37.46,89.41 37.46,87.36 37.83,86.99 37.83,86.33 37.55,86.05 37.55,82.16 37.01,81.63 ; 4 cut-outs
3D3V_S5 on TOP: 88.02,90.42 85.5,92.93 85.5,97.5 85,98.01 83.47,98.01 78.77,102.71 74.84,102.71 73.18,104.36 73.18,105 73.31,105.12 73.69,105.12 75.34,103.47 79.28,103.47 83.6,99.15 85.88,99.15 86.65,98.39 86.65,93.06 88.28,91.42 89.94,91.42 90.2,91.15 90.2,90.57 90.05,90.42
3D3V_S5 on TOP: 74.58,109.95 74.45,110.08 74.45,111.37 74.45,111.37 74.45,111.48 74.3,111.63 73.5,111.63 73.11,111.24 71.8,111.24 71.75,111.29 71.75,113.03 71.86,113.14 75.51,113.14 75.6,113.06 75.6,111.73 75.47,111.6 75.47,110.08 75.34,109.95 ; 2 cut-outs
3D3V_S5 on BOTTOM: 38.01,94.07 37.75,94.33 37.75,95.22 37.23,95.74 37.23,100.75 38.11,101.63 40.36,101.63 40.42,101.57 41.43,101.57 41.94,102.08 42.7,102.08 43.09,101.69 43.09,100.93 42.2,100.04 40.51,100.04 39.12,98.65 39.12,96.35 40.31,95.15 40.31,94.23 40.16,94.07
3D3V_S5 on BOTTOM: 34.96,3.78 34.58,4.16 33.18,4.16 32.93,4.41 32.93,5.81 32.67,6.06 30,6.06 29.62,6.44 29.62,8.86 29.88,9.11 33.56,9.11 34.96,7.71 34.96,7.33 34.58,6.95 34.58,6.44 35.72,5.3 35.72,4.03 35.47,3.78 ; 1 cut-out
3D3V_S5 on BOTTOM: 142.4,64.48 142.27,64.61 142.27,66.01 142.65,66.39 144.56,66.39 144.81,66.64 144.81,69.44 144.43,69.82 143.92,69.82 142.78,70.96 142.78,72.36 143.29,72.87 143.29,75.41 141.51,77.18 141.51,81.37 139.1,83.79 139.1,84.17 139.38,84.45 140.09,84.45 142.53,82.01 142.53,77.31 144.81,75.02 144.81,72.61 144.56,72.36 144.18,72.36 143.92,72.1 143.92,71.09 144.18,70.83 146.46,70.83 146.97,70.33 146.97,66.39 145.7,65.12 143.16,65.12 143.03,64.99 143.03,64.61 142.91,64.48
3D3V_S5 on BOTTOM: 100.87,24.35 100.74,24.48 100.74,25.24 100.62,25.37 99.85,25.37 99.73,25.49 99.73,26 99.98,26.26 101.25,26.26 101.89,26.89 101.89,27.78 102.14,28.03 102.9,28.03 103.03,27.91 103.03,26.13 102.39,25.49 102.39,24.73 102.01,24.35 ; 1 cut-out
3D3V_S5 on BOTTOM: 32.93,81.63 32.67,81.88 32.67,83.91 33.31,84.55 33.31,89.63 33.56,89.88 35.47,89.88 35.72,89.63 35.72,88.11 35.85,87.98 37.24,87.98 37.88,88.61 39.02,88.61 39.02,87.6 39.53,87.09 39.53,86.84 39.4,86.71 39.02,86.71 38.64,86.33 36.61,86.33 36.48,86.2 36.48,85.18 36.61,85.06 37.62,85.06 38.01,84.68 38.01,82.9 36.74,81.63 ; 2 cut-outs
3D3V_S5 on L3: 30,40.35 25.05,45.31 25.05,46.7 26.45,48.1 26.45,55.21 23.02,58.64 23.02,65.12 21.83,66.31 21.83,75.79 22.33,76.29 22.33,77.69 22.84,78.2 22.84,85.64 24.04,86.84 31.91,86.84 32.93,87.85 32.93,90.26 37.5,94.84 40.42,94.84 40.8,94.46 40.8,92.42 40.23,91.85 37.5,91.85 35.85,90.2 35.85,89.76 36.99,88.61 36.99,82.39 36.35,81.76 32.93,81.76 32.67,82.01 32.67,83.66 32.16,84.17 25.69,84.17 25.56,84.04 25.56,80.99 25.69,80.87 25.69,71.09 26.83,69.94 26.83,62.45 28.35,60.93 28.35,57.37 28.99,56.74 28.99,47.72 27.59,46.32 27.59,45.05 30.39,42.26 31.02,42.26 31.27,42 31.27,40.73 30.89,40.35
3D3V_S5 on L3: 142.15,65.75 142.15,64.86 142.53,64.48 143.54,64.48 144.56,65.5 144.56,73.5 144.3,73.75 143.54,73.75 143.29,73.5 143.29,66.52 142.78,66.01 142.4,66.01
3D3V_S5 on L3: 111.28,114.65 111.92,114.01 111.92,112.49 111.28,111.85 78.9,111.85 73.95,106.9 73.95,104.49 69.76,100.3 65.06,100.3 64.55,100.81 64.17,100.81 63.02,99.66 60.87,99.66 60.48,100.04 55.79,100.04 55.15,100.68 54.39,100.68 53.5,101.57 50.07,101.57 49.82,101.82 45.37,101.82 44.86,101.31 41.94,101.31 41.82,101.44 41.82,103.22 42.2,103.6 54.39,103.6 54.52,103.47 65.06,103.47 66.71,101.82 69.5,101.82 71.28,103.6 71.28,111.09 74.84,114.65
3D3V_S5 on L4: 35.47,94.07 33.75,95.79 32.61,95.79 31.78,96.61 31.78,100.3 35.21,103.73 56.55,103.73 56.8,103.47 65.06,103.47 66.71,101.82 69.5,101.82 71.28,103.6 71.28,111.09 74.84,114.65 111.54,114.65 112.05,114.14 112.05,112.49 111.28,111.73 77.63,111.73 74.84,108.93 74.84,102.84 71.66,99.66 65.06,99.66 64.8,99.41 61.12,99.41 60.48,100.04 59.85,100.04 59.21,99.41 48.8,99.41 48.42,99.79 41.56,99.79 40.93,100.42 35.59,100.42 35.08,99.92 35.08,98.8 37,96.88 40.02,96.88 40.55,96.36 40.55,94.33 40.29,94.07
3D3V_S5 on L4: 35.34,7.08 35.34,11.02 33.18,13.18 33.18,15.84 33.69,16.35 33.69,17.11 34.2,17.62 34.2,26 33.31,26.89 33.31,39.66 31.18,41.78 29.53,41.78 28.99,41.24 28.99,40.1 30.89,38.19 30.89,31.21 30.51,30.83 30.51,24.73 31.27,23.97 31.27,20.67 30.77,20.16 30.77,17.62 30.13,16.99 30.13,10.76 32.42,8.48 32.42,6.83 32.93,6.32 34.58,6.32
3D3V_S5 on L4: 36.61,89.76 36.99,89.38 36.99,82.39 36.61,82.01 32.8,82.01 32.29,82.52 32.29,89.38 32.67,89.76
3D3V_S5 on L5GND: 144,72.42 143.35,73.07 143.35,76.87 139.8,81.06 139.8,83.61 138.78,84.63 138.78,87.17 138.14,87.8 138.14,100 135.4,102.74 127.2,106.46 114.66,106.46 109.7,111.43 109.7,113.68 110.22,114.2 111.97,114.2 112.62,113.55 112.62,111.92 113.04,111.35 115.65,108.74 128,108.74 134.87,104.99 140.2,100.26 140.18,88.41 140.83,87.76 141.45,84.88 141.95,83.5 141.95,81.56 145.51,77.12 145.51,73.2 144.73,72.42
3D3V_S5_KBC on TOP: 144.05,53.56 144.05,53.82 144.69,54.45 145.07,54.45 145.57,54.96 145.57,56.1 144.94,56.74 144.94,58.64 144.69,58.9 143.8,58.9 143.67,58.77 143.67,58.01 143.54,57.88 143.16,57.88 143.03,58.01 143.03,59.02 142.4,59.66 142.4,60.8 142.65,61.05 143.92,61.05 144.18,60.8 144.18,60.42 144.43,60.17 145.45,60.17 145.7,59.91 145.7,56.74 146.13,56.31 146.13,53.99 145.7,53.56 ; 1 cut-out
3D3V_S5_KBC on TOP: 154.59,23.21 154.34,23.46 154.34,34.64 154.72,35.02 154.72,37.56 154.6,37.68 153.85,37.68 153.67,37.5 153.67,37.15 153.45,36.94 153.01,36.94 152.94,37 152.94,37.69 153.07,37.81 153.07,38.32 153.45,38.7 154.46,38.7 155.88,37.29 155.88,36.42 156.34,36.42 156.48,36.27 156.48,34.37 155.99,33.88 155.99,32.86 156.37,32.48 156.37,29.18 156.62,28.92 156.62,25.11 156.37,24.86 155.86,24.86 155.73,24.73 155.73,23.46 155.48,23.21 ; 1 cut-out
3D3V_S5_PCH on TOP: 77.9,91.03 77.88,91.05 77.88,92.14 78.01,92.27 78.01,94.2 78.14,94.33 79.53,94.33 79.76,94.1 79.76,93.28 79.59,93.12 79.59,91.34 79.28,91.03 ; 5 cut-outs
3D3V_S5_PCH on TOP: 88.17,88.23 88.04,88.36 88.04,89.63 88.09,89.68 89.06,89.68 89.06,89.38 89.31,89.12 89.31,88.36 89.19,88.23
3D3V_S5_PCH on TOP: 139.86,98.52 139.73,98.65 139.73,99.28 139.48,99.54 138.84,99.54 138.21,98.9 136.68,98.9 132.6,102.98 130.48,102.98 127.68,105.78 127.68,107.4 127.03,108.04 114.46,108.04 111.79,110.71 111.79,113 111.28,113.51 81.19,113.51 79.61,111.93 79.61,109.39 77.5,107.28 77.5,105.27 77.9,104.87 78.65,104.87 78.77,104.74 80.3,104.74 80.55,104.49 80.55,103.85 80.3,103.6 76.74,103.6 76.11,104.23 76.11,105.5 76.25,105.65 76.25,107.91 78.39,110.05 78.39,112.36 78.4,112.37 78.4,113.08 78.14,113.34 71.42,113.34 71.05,112.96 71.05,111.28 71.01,111.24 69.94,111.24 69.87,111.31 69.87,113.77 70.7,114.59 80.62,114.59 80.68,114.65 112.3,114.65 113.57,113.38 113.57,111.22 115.73,109.06 127.79,109.06 129.57,107.28 129.57,105.89 130.59,104.87 131.17,104.87 131.33,104.71 131.33,104.25 131.47,104.11 133.38,104.11 135.54,101.95 135.54,101.31 136.43,100.42 139.61,100.42 140.37,99.66 140.37,98.65 140.24,98.52 ; 2 cut-outs
3D3V_S5_PCH on BOTTOM: 84.74,86.71 84.61,86.84 84.61,89.12 84.11,89.63 83.09,89.63 82.71,89.25 80.68,89.25 79.79,90.14 79.53,90.14 78.65,91.03 78.65,92.42 78.9,92.68 79.41,92.68 79.66,92.42 79.66,91.66 80.17,91.15 80.55,91.15 81.44,90.26 82.2,90.26 82.71,90.77 84.49,90.77 85.63,89.63 85.63,86.84 85.5,86.71
3D3V_S5_PCH on BOTTOM: 63.41,75.15 63.15,75.41 63.15,78.33 63.2,78.38 64.09,78.38 64.19,78.28 64.19,77.9 64.32,77.77 64.32,75.18 64.29,75.15
3D3V_S5_PCH on L3: 79.66,104.87 80.42,104.87 80.68,104.62 80.68,99.66 79.66,98.65 79.66,92.04 79.28,91.66 78.65,91.66 78.39,91.92 78.39,99.28 79.41,100.3 79.41,104.62
3D3V_SEN_S0 on BOTTOM: 30.13,90.26 29.88,90.52 29.88,91.03 29.62,91.28 28.99,91.28 28.86,91.41 28.86,95.34 29.62,95.34 31.02,93.95 31.53,93.95 31.66,93.82 31.66,92.3 31.53,92.17 31.53,90.39 31.4,90.26 ; 3 cut-outs
3D3V_SPIVCC1 on TOP: 131.6,104.3 131.54,104.36 131.54,104.68 131.23,105 130.72,105 130.36,105.35 130.36,105.95 130.54,106.14 132.36,106.14 132.98,105.51 132.98,104.39 132.9,104.3 ; 1 cut-out
3D3V_SPIVCC1 on BOTTOM: 130.08,102.71 129.7,103.09 129.7,104.11 128.68,105.12 126.27,105.12 126.02,105.38 126.02,105.76 126.27,106.01 128.18,106.01 128.56,106.39 130.33,106.39 131.35,105.38 131.35,102.84 131.22,102.71
3D3V_SPIVCC2 on TOP: 137.83,97.88 137.7,98.01 137.7,98.52 137.83,98.65 138.46,98.65 138.72,98.9 138.72,99.15 138.97,99.41 139.35,99.41 139.48,99.28 139.48,98.52 138.84,97.88
3D3V_SPIVCC2 on BOTTOM: 138.97,95.85 138.84,95.98 138.84,97.88 137.83,98.9 137.83,100.17 137.95,100.3 138.34,100.3 138.59,100.55 138.59,101.19 138.61,101.21 139.55,101.21 139.61,101.16 139.61,95.98 139.48,95.85 ; 1 cut-out
81208_AGND on TOP: 36.61,46.58 36.35,46.83 35.72,46.83 35.21,47.34 34.35,47.34 34.22,47.47 32.34,47.47 32.26,47.39 32.26,46.96 31.78,46.96 31.66,47.08 31.66,48.35 31.27,48.74 31.27,51.53 31.4,51.66 31.91,51.66 32.29,52.04 35.59,52.04 35.85,52.29 35.85,52.55 35.97,52.67 36.35,52.67 36.48,52.55 36.48,47.59 37.12,46.96 37.12,46.83 36.86,46.58 ; 19 cut-outs
81208_AGND on L6: 32.16,52.16 35.21,52.16 35.85,51.53 35.85,48.1 35.34,47.59 32.16,47.59 31.53,48.23 31.53,51.53
+DC_IN on TOP: 34.7,29.94 33.05,31.59 29.37,31.59 28.48,32.48 28.48,33.62 27.85,34.26 27.85,36.04 26.83,37.05 26.32,37.05 25.69,36.42 23.65,36.42 16.16,43.91 16.16,63.47 16.8,64.1 16.8,64.61 18,65.82 18,66.83 18.96,67.79 18.96,68.67 19.72,69.44 19.72,70.58 20.35,71.21 20.35,74.52 19.97,74.9 19.46,74.9 19.45,74.91 19.22,74.91 18.29,75.84 18.29,78.94 17.28,79.95 17.28,82.87 18.32,83.91 18.32,86.23 19.41,87.32 19.41,88.74 19.54,88.87 21.5,88.87 21.75,88.61 21.75,87.34 22.9,86.19 23.84,86.19 25.05,84.98 25.05,80.61 25.36,80.31 25.36,76.75 25.94,76.17 25.94,74.31 24.64,73.66 25.94,73 25.94,71.98 25.37,71.21 25.94,70.45 25.94,58.26 22.38,54.7 22.38,50.51 25.62,47.28 25.62,45.18 30.1,40.7 31.31,40.7 32.16,39.85 32.8,39.85 38.51,34.13 38.51,30.96 37.5,29.94 ; 5 cut-outs
+DC_IN on BOTTOM: 34.2,28.54 34.07,28.67 34.07,34.64 34.32,34.89 39.22,34.89 39.47,34.64 39.47,31.28 39.15,30.96 38.13,30.96 38.01,30.83 38.01,28.54 ; 2 cut-outs
+DC_IN on BOTTOM: 18.83,88.74 18.96,88.87 23.44,88.87 23.59,88.72 23.59,87.53 24.29,86.84 24.29,86.45 24.16,86.33 23.65,86.33 22.26,84.93 20.91,84.93 20.66,84.68 19.34,84.68 18.83,85.18
+SDC_IN on BOTTOM: 41.18,21.68 40.8,22.07 39.53,22.07 39.53,24.73 40.55,25.75 42.83,25.75 42.96,25.62 42.96,21.81 42.83,21.68
+VCHGR on TOP: 78.9,20.8 76.87,22.83 75.34,22.83 75.09,23.08 75.09,24.86 78.52,28.29 83.73,28.29 83.85,28.16 83.85,21.43 83.22,20.8 ; 1 cut-out
+VCHGR on BOTTOM: 78.77,20.8 76.87,22.7 75.22,22.7 74.84,23.08 74.84,27.78 75.09,28.03 80.17,28.03 80.8,27.4 80.8,25.37 80.93,25.24 82.2,25.24 82.2,21.05 81.95,20.8
AD+ on BOTTOM: 34.45,20.92 34.2,21.18 34.2,23.59 34.07,23.72 33.56,23.72 33.43,23.84 33.43,24.86 33.56,24.99 35.34,24.99 35.72,25.37 35.72,28.03 35.85,28.16 39.15,28.16 39.15,20.92 ; 3 cut-outs
AUD_AGND on TOP: 19.08,16.73 17.3,18.51 17.18,18.51 17.05,18.64 14.89,18.64 11.34,22.19 1.3,22.19 1.18,22.32 1.18,23.84 1.43,24.1 12.35,24.1 13.11,24.86 13.11,26 12.61,26.51 12.61,31.21 13.11,31.72 13.11,33.75 13.37,34 16.03,34 16.16,33.88 16.16,32.61 16.67,32.1 16.67,29.94 14.64,27.91 13.75,27.91 13.24,27.4 13.24,26.51 13.88,25.88 13.88,25.11 13.62,24.86 13.62,22.32 15.4,20.54 15.65,20.54 16.29,19.91 17.05,19.91 17.3,19.65 17.3,19.02 17.43,18.89 17.94,18.89 18.83,18 19.72,18 20.23,17.49 20.23,16.86 20.1,16.73 ; 2 cut-outs
AUD_AGND on BOTTOM: 19.21,16.73 18.83,17.11 18.83,17.37 18.96,17.49 19.21,17.49 19.34,17.37 20.86,17.37 21.37,17.87 21.37,19.65 21.24,19.78 19.72,19.78 19.59,19.91 19.59,20.8 19.34,21.05 19.34,22.57 18.32,23.59 18.32,24.35 17.56,25.11 17.56,25.88 17.43,26 17.43,28.54 17.05,28.92 15.4,28.92 14.13,27.65 13.88,27.65 13.62,27.91 13.62,30.45 15.02,31.84 16.54,31.84 17.81,30.57 19.34,30.57 19.59,30.32 19.59,30.07 20.73,28.92 20.73,28.42 20.61,28.29 20.1,28.29 19.97,28.42 19.97,28.8 19.59,29.18 18.83,29.18 18.19,28.54 18.19,25.75 18.45,25.49 19.59,25.49 19.72,25.37 19.72,23.34 20.23,22.83 21.62,22.83 21.75,22.7 21.75,22.19 21.62,22.07 21.24,22.07 20.61,21.43 20.61,20.92 20.99,20.54 21.88,20.54 22.13,20.29 22.13,17.62 21.24,16.73 ; 6 cut-outs
AUD_AGND on L2VCC: 19.16,16.8 17.26,18.7 14.84,18.7 11.41,22.13 0.91,22.13 0.91,23.9 1.05,24.25 1.4,24.39 11.85,24.39 12.82,25.14 12.36,26.27 12.36,31.38 12.82,32.51 11.85,33.26 1.4,33.26 1.05,33.4 0.91,33.75 0.91,34.79 0.98,35.05 1.18,35.23 1.49,35.44 1.74,35.72 14.59,35.72 15.86,36.99 21.42,36.99 21.94,36.47 21.94,35.48 21.54,35.08 20.91,35.08 19.78,33.96 19.78,29.86 20.92,28.72 20.92,27.35 20.91,27.34 20.02,27.34 19.65,26.97 19.65,23.26 20.02,22.89 21.67,22.89 21.81,22.75 21.81,21.86 22.07,21.61 22.07,16.94 21.92,16.8
AUD_AGND on L6: 19.16,16.8 17.26,18.7 14.84,18.7 11.41,22.13 0.91,22.13 0.91,23.9 1.05,24.25 1.4,24.39 11.85,24.39 12.82,25.14 12.36,26.27 12.36,31.38 12.82,32.51 11.85,33.26 1.4,33.26 1.05,33.4 0.91,33.75 0.91,34.79 0.98,35.05 1.18,35.23 1.49,35.44 1.74,35.72 14.59,35.72 15.86,36.99 21.09,36.99 21.25,36.82 21.27,36.82 21.27,35.44 19.21,33.38 19.21,29.56 20.92,27.84 20.92,27.35 20.91,27.34 20.02,27.34 19.65,26.97 19.65,24.73 19.72,24.73 19.46,24.48 18.19,24.48 17.3,25.37 14.89,25.37 14.64,25.11 14.64,24.73 15.78,23.59 16.29,23.59 17.56,22.32 18.19,22.32 18.7,22.83 19.97,22.83 20.03,22.89 21.67,22.89 21.81,22.75 21.81,21.86 22.07,21.61 22.07,16.94 21.92,16.8
AUD_AGND on L7GND: 19.16,16.8 17.26,18.7 14.84,18.7 11.41,22.13 0.91,22.13 0.91,23.9 1.05,24.25 1.4,24.39 11.85,24.39 12.82,25.14 12.36,26.27 12.36,31.38 12.82,32.51 11.85,33.26 1.4,33.26 1.05,33.4 0.91,33.75 0.91,34.79 0.98,35.05 1.18,35.23 1.49,35.44 1.74,35.72 14.59,35.72 15.86,36.99 21.42,36.99 21.94,36.47 21.94,35.48 21.54,35.08 20.91,35.08 19.78,33.96 19.78,29.86 20.92,28.72 20.92,27.35 20.91,27.34 20.02,27.34 19.65,26.97 19.65,23.26 20.02,22.89 21.67,22.89 21.81,22.75 21.81,21.86 22.07,21.61 22.07,16.94 21.92,16.8
AUD_SPK_L+ on BOTTOM: 16.29,14.06 16.16,14.19 16.16,14.95 16.29,15.08 18.32,15.08 18.45,14.95 18.45,14.19 18.32,14.06
AUD_SPK_L+_C on BOTTOM: 12.1,10.76 11.84,11.02 11.84,11.52 13.62,13.3 14.38,13.3 14.89,13.81 14.89,14.95 15.02,15.08 15.65,15.08 15.78,14.95 15.78,14.19 16.16,13.81 16.8,13.81 16.92,13.68 16.92,13.3 16.8,13.18 15.78,13.18 14.89,12.29 14.13,12.29 12.61,10.76
AUD_SPK_L- on BOTTOM: 16.29,15.33 16.16,15.46 16.16,16.22 16.29,16.35 17.94,16.35 18.19,16.1 18.19,15.59 17.94,15.33
AUD_SPK_L-_C on BOTTOM: 10.83,10.64 10.57,10.89 10.57,12.03 13.62,15.08 13.62,15.33 14.89,16.6 14.89,17.11 15.02,17.24 15.4,17.24 15.53,17.11 15.53,16.6 15.78,16.35 15.78,15.46 15.65,15.33 15.02,15.33 14.64,14.95 14.64,14.57 11.59,11.52 11.59,10.89 11.34,10.64
AUD_SPK_R+ on TOP: 16.16,7.59 16.03,7.71 16.03,8.6 15.78,8.86 15.78,9.49 16.26,9.98 17.23,9.98 17.76,9.44 17.76,8.43 16.92,7.59
AUD_SPK_R+_C on TOP: 14,7.59 13.75,7.84 13.75,8.35 14,8.6 14.64,8.6 14.76,8.73 14.76,9.37 14.89,9.49 15.4,9.49 15.53,9.37 15.53,8.73 15.65,8.6 15.65,7.71 15.53,7.59
AUD_SPK_R- on TOP: 16.16,6.19 16.03,6.32 16.03,7.21 16.16,7.33 17.05,7.33 17.56,7.84 18.07,7.84 18.7,7.21 18.7,6.57 18.32,6.19
AUD_SPK_R-_C on TOP: 14.89,5.43 14.76,5.56 14.76,6.06 14.51,6.32 13.24,6.32 12.99,6.57 12.99,7.21 13.24,7.46 13.88,7.46 14,7.33 15.53,7.33 15.65,7.21 15.65,6.19 15.53,6.06 15.53,5.56 15.4,5.43
BQ24770_AGND on BOTTOM: 36.35,12.03 36.23,12.16 36.23,12.41 36.35,12.54 36.86,12.54 37.12,12.79 37.12,14.95 36.23,15.84 35.59,15.84 35.47,15.97 35.47,16.48 35.59,16.6 36.61,16.6 38.26,14.95 42.32,14.95 44.48,17.11 46.01,17.11 46.26,16.86 46.26,15.08 46.51,14.83 46.51,14.06 46.39,13.94 45.12,13.94 43.34,12.16 37.88,12.16 37.75,12.03
BT+ on TOP: 84.74,17.24 84.36,17.62 84.36,19.65 84.23,19.78 84.23,27.65 84.36,27.78 86.01,27.78 87.79,26 88.55,26 88.68,25.88 88.68,24.1 89.44,23.34 89.44,18.89 89.19,18.64 89.19,17.49 88.93,17.24
BT+ on BOTTOM: 84.74,17.24 84.36,17.62 84.36,19.65 82.58,21.43 82.58,26.51 82.71,26.64 82.73,26.64 83.12,27.02 84.51,27.02 84.74,27.25 84.74,28.19 84.87,28.31 85.6,28.31 85.78,28.14 85.78,27.22 86.14,26.87 86.93,26.87 88.04,25.75 88.04,22.83 89.44,21.43 89.44,19.02 89.06,18.64 89.06,17.49 88.81,17.24 ; 2 cut-outs
CHARGER_SRC on BOTTOM: 46.64,17.62 45.88,18.38 44.61,18.38 43.47,19.53 43.47,25.62 43.59,25.75 47.02,25.75 47.28,26 47.78,26 48.04,25.75 48.04,22.07 48.29,21.81 53.37,21.81 53.5,21.68 53.5,21.05 53.37,20.92 52.23,20.92 51.98,20.67 51.98,19.27 52.48,18.76 52.48,17.75 52.36,17.62 ; 1 cut-out
DCBATOUT on TOP: outline of 164 points within 28.48,16.68 133.79,102.36 ; 27 cut-outs
DCBATOUT on BOTTOM: 118.27,16.48 118.02,16.73 107.6,16.73 107.35,16.99 107.35,19.14 107.6,19.4 118.9,19.4 119.4,18.9 119.41,18.92 123.4,18.92 123.53,19.04 137.95,19.04 138.46,19.55 138.46,22.45 139.8,23.78 139.8,25.81 139.35,26.26 139.35,27.27 138.46,28.16 138.46,28.8 138.21,29.05 138.21,30.45 137.83,30.83 137.83,37.05 137.81,37.06 137.81,39.55 137.32,40.05 137.32,42 137.07,42.26 137.07,43.78 139.1,43.78 139.48,43.4 139.48,43.02 139.61,42.89 140.37,42.89 140.88,42.39 142.27,42.39 142.4,42.26 142.4,41.24 140.71,39.56 140.71,38.97 140.49,38.75 140.49,36.8 140.24,36.54 140.24,34.89 139.99,34.64 139.99,32.73 142.37,30.35 142.37,29.47 143.8,28.03 143.8,24.89 141.75,22.84 141.75,22.32 141.26,21.82 141.26,17.49 140.24,16.48 131.65,16.48 130.44,17.7 124.54,17.7 123.37,16.53 123.37,16.48 ; 2 cut-outs
DCBATOUT on BOTTOM: 59.73,20.67 59.18,21.22 59.18,25.78 57.83,27.13 53.91,27.13 49.56,31.49 46.46,31.49 42.08,35.86 42.08,41.83 42.23,41.99 42.23,46.05 42.59,46.41 45.03,46.41 45.57,46.96 46.9,46.96 46.9,43.78 47.28,43.4 47.28,39.21 48.66,37.83 51.53,37.83 51.92,37.43 54.92,37.43 58.6,33.75 69.09,33.75 69.17,33.67 69.17,32.2 69.53,31.84 69.53,28.34 69.76,28.11 71.18,28.11 71.28,28.01 71.28,22.83 71.15,22.7 68.23,22.7 67.85,22.32 67.85,21.3 67.22,20.67 ; 2 cut-outs
DCBATOUT on BOTTOM: 38.64,76.68 38.13,77.18 38.13,82.01 39.66,83.53 39.66,85.44 39.91,85.69 41.43,85.69 41.56,85.82 42.55,85.82 42.6,85.77 42.6,83.69 42.32,83.41 42.32,80.61 40.8,79.09 40.8,76.93 40.55,76.68 ; 2 cut-outs
DCBATOUT on BOTTOM: 41.94,51.4 41.82,51.53 41.82,52.04 40.04,53.82 38.89,53.82 38.13,54.58 38.13,60.67 38.26,60.8 39.66,60.8 40.93,59.53 42.2,59.53 42.32,59.4 42.32,56.36 42.7,55.97 42.96,55.97 43.34,55.59 43.34,51.78 42.96,51.4 ; 4 cut-outs
DCBATOUT on BOTTOM: 37.62,69.44 37.12,69.94 31.32,69.94 31.03,70.23 26.67,70.23 26.58,70.33 26.58,72.36 26.73,72.51 29.8,72.51 30.66,73.37 33.43,73.37 33.81,73.75 33.81,74.77 33.94,74.9 37.24,74.9 37.75,74.39 42.07,74.39 42.64,74.96 42.64,75.29 42.69,75.34 45.46,75.34 45.5,75.31 45.5,71.6 45.12,71.21 43.34,71.21 41.56,69.44 ; 2 cut-outs
DCBATOUT on L6: 37.9,52.98 37.9,54.2 36.48,55.62 36.48,60.93 35.72,61.69 35.72,64.48 36.99,65.75 37.01,65.75 37.64,66.38 37.64,82.15 38.89,83.41 41.05,83.41 41.69,82.77 41.69,80.99 40.8,80.1 40.8,76.93 41.82,75.91 41.82,68.29 42.96,67.15 42.96,64.61 41.33,62.99 41.33,61.18 42.35,60.17 42.35,56.84 45.5,53.69 45.5,49.88 46.77,48.61 46.77,41.75 46.39,41.37 42.58,41.37 41.56,42.39 41.56,44.8 40.86,45.5 39.47,45.5 38.64,46.32 38.64,52.24
DCBATOUT_LCD on TOP: 65.91,93.39 65.81,93.48 64.08,93.48 63.91,93.65 63.91,98.65 62.64,99.92 62.64,102.33 62.66,102.35 63.91,102.35 63.95,102.31 63.95,101.53 65.82,99.66 66.2,99.66 66.33,99.54 66.33,94.48 66.65,94.16 66.65,93.5 66.54,93.39 ; 3 cut-outs
DCBATOUT_LCD on BOTTOM: 61.95,91.32 61.88,91.38 61.88,94.58 62.01,94.71 64.8,94.71 65.56,93.95 65.56,93.44 65.44,93.31 64.04,93.31 63.91,93.19 63.91,92.8 63.95,92.77 63.95,91.45 63.82,91.32
DDR_VREF_S3 on TOP: 122.46,32.86 122.33,32.99 122.33,33.37 122.46,33.5 123.86,33.5 124.62,34.26 126.65,34.26 126.91,34 127.92,34 129.7,35.78 129.7,53.43 134.53,58.26 134.53,63.47 136.43,65.37 136.43,66.64 134.91,68.17 134.91,72.48 135.29,72.87 135.29,79.47 134.91,79.85 134.02,79.85 132.87,80.99 132.87,82.39 133,82.52 133.26,82.52 133.38,82.39 133.38,81.25 134.27,80.36 135.16,80.36 135.8,79.72 135.8,72.48 135.54,72.23 135.54,68.29 136.94,66.9 136.94,64.99 135.16,63.21 135.16,58.01 130.21,53.05 130.21,35.53 128.05,33.37 126.65,33.37 126.27,33.75 125.13,33.75 124.24,32.86
EDRAM_OPIO_RCOMP on TOP: 73.39,45.92 73.31,45.99 73.31,46.83 73.69,47.21 74.73,47.21 74.78,47.16 74.78,46.65 74.71,46.58 74.38,46.58 73.97,46.17 73.97,46.04 73.84,45.92
EOPIO_RCOMP on TOP: 73.72,47.42 73.36,47.77 73.36,48.25 73.44,48.33 74.25,48.33 74.3,48.38 74.76,48.38 74.81,48.33 74.81,47.52 74.71,47.42 ; 1 cut-out
FAN_VCC_1 on BOTTOM: 137.7,68.67 137.57,68.8 137.57,73.25 138.34,74.01 138.34,75.02 138.54,75.23 139.45,75.23 139.88,74.8 139.88,70.35 139.48,69.94 139.48,68.8 139.35,68.67 ; 4 cut-outs
HGNDA on BOTTOM: 14.64,19.27 14,19.91 13.49,19.91 12.48,20.92 12.48,21.56 12.73,21.81 13.24,21.81 14,21.05 14.51,21.05 14.76,20.8 14.76,20.54 15.02,20.29 15.15,20.29 15.27,20.41 15.27,20.54 15.02,20.8 15.02,21.43 15.15,21.56 16.03,21.56 16.29,21.3 16.29,19.53 16.03,19.27
HGNDB on TOP: 17.81,34.26 17.69,34.38 17.69,35.15 17.43,35.4 16.03,35.4 15.15,34.51 13.62,34.51 13.49,34.64 13.49,35.4 13.62,35.53 14.64,35.53 15.4,36.29 17.56,36.29 18.07,36.8 18.45,36.8 18.7,36.54 18.7,34.38 18.57,34.26
HSIO_OUT on TOP: 65.13,82.62 64.85,82.9 60.53,82.9 60.31,83.13 60.31,85.24 60.41,85.34 61.98,85.34 62.39,84.93 64.88,84.93 65.54,84.27 65.54,82.75 65.41,82.62
KB_BL_CTRL# on BOTTOM: 21.9,9.47 21.88,9.49 21.88,12.29 21.5,12.67 21.5,13.05 21.62,13.18 22.13,13.18 22.77,12.54 22.77,9.59 22.64,9.47
LCDVDD on TOP: 44.23,95.47 43.97,95.73 43.97,99.03 43.82,99.18 43.82,99.66 43.83,99.68 43.83,99.9 43.97,100.04 45.24,100.04 45.5,99.79 46.51,99.79 46.77,99.54 46.77,99.03 48.93,99.03 49.05,98.9 49.05,97.63 48.29,96.87 46.26,96.87 46.01,96.61 46.01,95.73 45.75,95.47 ; 3 cut-outs
LCDVDD on BOTTOM: 44.89,93.39 44.89,94.81 44.61,95.09 44.23,95.09 44.1,95.22 44.1,96.36 44.48,96.74 45.88,96.74 46.13,96.49 46.13,95.47 45.7,95.04 45.7,93.41 45.68,93.39 45.4,93.39 45.4,94.71 45.35,94.76 45.24,94.76 45.19,94.71 45.19,93.39
M_VREF_CA_DIMMA on TOP: 135.41,65.12 133.38,67.15 133.38,70.58 130.08,73.88 128.05,73.88 127.92,74.01 127.92,74.52 128.05,74.64 128.05,75.53 128.18,75.66 130.97,75.66 132.11,74.52 132.11,73.5 134.53,71.09 134.53,67.91 135.8,66.64 135.92,66.64 136.18,66.39 136.18,65.37 135.92,65.12 ; 4 cut-outs
M_VREF_CA_DIMMA on BOTTOM: 135.67,65.12 135.41,65.37 135.41,66.52 135.54,66.64 137.45,66.64 137.57,66.52 137.57,65.25 137.45,65.12 ; 2 cut-outs
M_VREF_DQ_DIM0 on TOP: 119.93,32.88 118.62,34.19 118.62,41.01 113.19,46.45 102.14,46.45 101.12,45.43 95.65,45.43 93.63,43.4 91.35,43.4 90.58,44.16 90.58,44.42 90.84,44.67 91.22,44.67 91.73,44.16 93.25,44.16 95.28,46.2 100.62,46.2 101.76,47.34 113.44,47.34 120.05,40.73 120.05,34.26 120.56,33.75 121.06,33.75 121.19,33.62 121.92,33.62 121.99,33.56 121.99,32.98 121.88,32.88 ; 2 cut-outs
M_VREF_DQ_DIMMA on TOP: 122.33,33.75 122.21,33.88 121.57,33.88 121.44,34 121.44,34.51 121.7,34.77 121.7,35.4 121.83,35.53 122.59,35.53 122.71,35.4 122.71,34.77 122.97,34.51 123.6,34.51 123.73,34.64 123.73,35.27 123.86,35.4 125.25,35.4 125.38,35.53 125.38,35.78 125.51,35.91 126.02,35.91 126.14,35.78 126.14,34.77 126.02,34.64 124.75,34.64 123.86,33.75 ; 2 cut-outs
PWR_1D0V_PH on BOTTOM: 45.73,82.54 45.65,82.63 45.65,83.74 44.77,84.63 43.67,84.63 43.67,84.63 43.67,85.77 43.68,85.78 45.2,85.78 46.26,86.84 48.03,86.84 48.18,86.69 48.18,82.58 48.14,82.54
PWR_1D35V_PHASE on BOTTOM: 137.07,44.93 137.07,46.07 136.71,46.42 136.07,46.42 135.54,46.96 135.54,48.53 136,48.99 139.1,48.99 139.35,48.74 139.35,46.96 138.34,45.94 138.34,44.93
PWR_3D3V_SW2 on BOTTOM: 31.81,76.8 31.57,77.04 31.57,79.64 31.91,79.98 34.96,79.98 35.21,79.72 35.21,77.06 34.96,76.8
PWR_5V_DRVH1 on BOTTOM: 25.69,70.86 25.43,71.11 25.43,72.08 25.58,72.23 26.3,72.23 26.45,72.08 26.45,70.96 26.35,70.86
PWR_5V_SW1 on BOTTOM: 25.28,74.16 25.08,74.36 25.08,78.83 25.33,79.09 29.19,79.09 29.5,78.78 29.5,75.41 29.37,75.28 28.63,75.28 28.25,74.9 28.25,74.54 27.87,74.16
PWR_CHG_PHASE on BOTTOM: 55.02,21.18 54.13,22.07 48.55,22.07 48.42,22.19 48.42,24.99 48.55,25.11 53.63,25.11 55.4,26.89 57.69,26.89 58.83,25.75 58.83,21.94 58.07,21.18
PWR_VCCGT_SWA on BOTTOM: 51.98,43.27 51.47,43.78 50.58,43.78 49.94,44.42 49.94,47.34 50.07,47.47 52.61,47.47 54.01,46.07 56.55,46.07 56.8,45.81 56.8,43.4 56.67,43.27
PWR_VCCSA_SW on BOTTOM: 45.85,73.09 45.84,73.1 45.84,75.7 45.12,76.42 44.48,76.42 44.29,76.42 44.21,76.5 44.21,79.91 44.28,79.98 48.17,79.98 49.69,78.45 49.69,73.59 49.55,73.46 47.72,73.46 47.35,73.09
PWR_VCORE_SW on BOTTOM: 47.02,56.1 46.01,57.12 45.63,57.12 45.37,57.37 45.37,59.66 45.5,59.78 48.8,59.78 49.82,58.77 51.98,58.77 52.36,58.39 52.36,56.36 52.1,56.1
Q6502_D on BOTTOM: 105.06,23.84 102.9,23.84 102.65,24.1 102.65,24.86 102.9,25.11 104.93,25.11 105.19,24.86 105.19,23.97
TP_VDD on TOP: 115.22,25.11 115.09,25.24 115.09,26.64 114.71,27.02 112.05,27.02 111.79,26.76 110.52,26.76 110.27,27.02 110.27,27.78 110.78,28.29 115.6,28.29 116.49,27.4 116.49,25.24 116.36,25.11 ; 3 cut-outs
TP_VDD on BOTTOM: 107.86,21.05 106.19,22.71 104.59,22.71 104.53,22.78 104.53,23.54 104.58,23.59 105.67,23.59 105.7,23.62 105.7,24.86 105.32,25.24 104.43,25.24 104.3,25.37 104.3,25.88 104.43,26 105.95,26 107.35,24.61 107.35,23.72 108.74,22.32 113.57,22.32 114.97,23.72 114.97,25.49 115.22,25.75 116.24,25.75 116.25,25.74 116.99,25.74 117.25,25.47 117.25,24.35 116.62,23.72 116.62,21.56 116.11,21.05
TPAN_VDD on TOP: 26.96,94.71 26.83,94.84 26.83,95.85 27.08,96.11 28.48,96.11 30.26,97.88 30.26,99.92 30.39,100.04 32.04,100.04 32.16,99.92 32.16,96.36 31.91,96.11 30,96.11 29.75,95.85 29.75,94.84 29.62,94.71 ; 1 cut-out
TPAN_VDD on BOTTOM: 26.19,94.71 26.07,94.84 26.07,96.49 26.58,97 28.15,97 28.73,96.41 29.75,96.41 29.75,96.08 28.78,96.08 28.58,95.88 28.58,95.07 28.23,94.71
U4101_OUT on TOP: 74.84,104.11 74.45,104.49 74.45,104.64 74.12,104.97 74.12,105.4 74.45,105.73 74.45,107.41 76.11,107.41 76.12,107.4 76.12,105.9 75.85,105.63 75.85,104.23 75.72,104.11 ; 1 cut-out
USB30_VCCA on BOTTOM: 24.16,55.47 24.16,59.4 22.77,60.8 22.77,64.99 22,65.75 12.73,65.75 12.22,66.26 12.22,67.4 12.61,67.79 23.27,67.79 25.05,66.01 25.05,61.69 26.32,60.42 26.32,56.23 25.56,55.47 ; 4 cut-outs
USB30_VCCB on BOTTOM: 19.46,47.21 18.83,47.85 18.07,47.85 17.94,47.72 13.88,47.72 13.37,48.23 13.37,49.88 13.75,50.26 17.18,50.26 17.69,50.77 18.96,50.77 19.08,50.64 19.08,50.39 19.21,50.26 19.46,50.26 20.48,49.24 23.15,49.24 23.27,49.12 23.27,48.1 23.02,47.85 22.13,47.85 21.5,47.21 ; 5 cut-outs
V_SM_VREF_CNT on TOP: 120.35,30.7 117.59,33.47 117.59,33.75 117.46,33.88 117.46,40.4 112.68,45.18 102.78,45.18 100.62,43.02 95.41,43.02 94.39,42 94.39,41.12 94.27,40.99 93.76,40.99 93.63,41.12 93.63,42.26 95.16,43.78 100.36,43.78 102.52,45.94 112.94,45.94 118.37,40.51 118.37,33.97 120.87,31.46 126.47,31.46 130.44,35.43 130.44,52.77 135.54,57.88 135.54,62.96 136.68,64.1 137.07,64.1 137.19,63.98 137.19,63.47 136.3,62.58 136.3,57.5 131.32,52.52 131.32,35.22 126.8,30.7

Small or netless copper shapes (teardrops, artwork): 4 on TOP, 5 on BOTTOM

## Text on the board
Ref Des/Silkscreen Bottom: F5502:0.5A/6V | F6501:0.5A/6V | CPU1 | F5504:1.1A/6V | X1802:32.768KHZ | X1801:24MHZ | X2401:32.768KHZ
Ref Des/Silkscreen Top: X6901:12MHZ | F5701:1.1A/6V | F5501:1.1A/24V | F5503:1.1A/24V | MADE IN TAIWAN | COTTONWOOD MLK MB | REV:A00 | 14275-1 | PWB:TFFRC
User.19: Remove | EMC | Controler | CPU_POWER | HDMI | 1D8V_POWER | VCCST | VCCSTG | CPU_PORTION | V1.8A | V1.8S | KBC
User.27: Board Accuracy Check,Jul 27 14:37:40 2015,Passed | Component Overlap Check,Apr 24 01:19:01 2015,93 errors | Dummy-Static-No Shape On Layer Check,Jul 27 14:37:40 2015,Passed | Split Plane Check,May 15 10:40:18 2015,Passed | TP Violations Check,Oct 23 11:41:53 2013,729 errors | Via On Moat Check,Oct 21 14:33:23 2013,117 errors
User.28: HEADER:Board Accuracy Check:1=show;2=show;3=show | HEADER:Dummy-Static-No Shape On Layer Check:1=show;2=hide;3=show;4=hide;5=show;6=show;7=show | HEADER:Split Plane Check:1=show;2=hide;3=show;4=hide;5=show;6=show;7=show
User.30: ByImpedance:100.0@_REF_L1=("4.0/10.0(L1)" "3.5/7.0(L1)")|_REF_L5GND=("4.0/9.0(L5GND)" "3.5/7.0(L5GND)")|_REF_L6=("4.0/12.0(L6)" "4.0/9.0(L6)" "3.5/7.0(L6)" "3.5/8.0(L6)")|Type="DP"|_REF_L4=("4.0/9.0(L4)" "3.5/7.0(L4)")|_REF_L3=("4.0/12.0(L3)" "4.0/9.0(L3)" "3.5/7.0(L3)" "3.5/8.0(L3)")|imp="100.0"|_REF_L8=("4.0/10.0(L8)" "3.5/7.0(L8)") | ByImpedance:110.0@_REF_L1=("nil(L1)")|_REF_L5GND=("nil(L5GND)")|_REF_L6=("nil(L6)")|Type="DP"|_REF_L4=("nil(L4)")|_REF_L3=("nil(L3)")|imp="110.0"|_REF_L8=("nil(L8)") | ByImpedance:33.0@_REF_L1=("10.0(L1)")|_REF_L5GND=("10.5(L5GND)")|_REF_L6=("10.5(L6)" "9.5(L6)")|Type="SE"|_REF_L4=("10.5(L4)")|_REF_L3=("10.5(L3)" "9.5(L3)")|imp="33.0"|_REF_L8=("10.0(L8)") | ByImpedance:35.0@_REF_L1=("9.0(L1)")|_REF_L5GND=("9.5(L5GND)")|_REF_L6=("8.5(L6)" "9.5(L6)")|Type="SE"|_REF_L4=("9.5(L4)")|_REF_L3=("8.5(L3)" "9.5(L3)")|imp="35.0"|_REF_L8=("9.0(L8)") | ByImpedance:37.5@_REF_L1=("8.0(L1)")|_REF_L5GND=("8.5(L5GND)")|_REF_L6=("8.5(L6)" "7.5(L6)")|Type="SE"|_REF_L4=("8.5(L4)")|_REF_L3=("8.5(L3)" "7.5(L3)")|imp="37.5"|_REF_L8=("8.0(L8)") | ByImpedance:39.0@_REF_L1=("7.5(L1)")|_REF_L5GND=("8.0(L5GND)")|_REF_L6=("7.0(L6)" "8.0(L6)")|Type="SE"|_REF_L4=("8.0(L4)")|_REF_L3=("8.0(L3)" "7.0(L3)")|imp="39.0"|_REF_L8=("7.5(L8)") | ByImpedance:40.0@_REF_L1=("7.0(L1)")|_REF_L5GND=("7.5(L5GND)")|_REF_L6=("6.5(L6)" "7.5(L6)")|Type="SE"|_REF_L4=("7.5(L4)")|_REF_L3=("6.5(L3)" "7.5(L3)")|imp="40.0"|_REF_L8=("7.0(L8)") | ByImpedance:45.0@_REF_L1=("5.5(L1)")|_REF_L5GND=("6.0(L5GND)")|_REF_L6=("6.0(L6)" "5.0(L6)")|Type="SE"|_REF_L4=("6.0(L4)")|_REF_L3=("6.0(L3)" "5.0(L3)")|imp="45.0"|_REF_L8=("5.5(L8)") | ByImpedance:48.0@_REF_L1=("5.0(L1)")|_REF_L5GND=("5.0(L5GND)")|_REF_L6=("4.5(L6)" "5.0(L6)")|Type="SE"|_REF_L4=("5.0(L4)")|_REF_L3=("4.5(L3)" "5.0(L3)")|imp="48.0"|_REF_L8=("5.0(L8)") | ByImpedance:50.0@_REF_L1=("4.5(L1)")|_REF_L5GND=("4.5(L5GND)")|_REF_L6=("4.5(L6)" "4.0(L6)")|Type="SE"|_REF_L4=("4.5(L4)")|_REF_L3=("4.5(L3)" "4.0(L3)")|imp="50.0"|_REF_L8=("4.5(L8)") | ByImpedance:55.0@_REF_L1=("3.5(L1)")|_REF_L5GND=("3.5(L5GND)")|_REF_L6=("3.5(L6)")|Type="SE"|_REF_L4=("3.5(L4)")|_REF_L3=("3.5(L3)")|imp="55.0"|_REF_L8=("3.5(L8)") | ByImpedance:60.0@_REF_L1=("9.5/5.0(L1)")|_REF_L5GND=("10.0/5.0(L5GND)")|_REF_L6=("9.5/5.0(L6)" "10.0/5.0(L6)")|Type="DP"|_REF_L4=("10.0/5.0(L4)")|_REF_L3=("10.0/5.0(L3)" "9.5/5.0(L3)")|imp="60.0"|_REF_L8=("9.5/5.0(L8)") | ByImpedance:65.0@_REF_L1=("8.5/5.0(L1)")|_REF_L5GND=("8.5/5.0(L5GND)")|_REF_L6=("8.0/5.0(L6)" "8.5/5.0(L6)")|Type="DP"|_REF_L4=("8.5/5.0(L4)")|_REF_L3=("8.0/5.0(L3)" "8.5/5.0(L3)")|imp="65.0"|_REF_L8=("8.5/5.0(L8)") | ByImpedance:70.0@_REF_L1=("7.0/5.0(L1)")|_REF_L5GND=("7.5/5.0(L5GND)")|_REF_L6=("7.0/5.0(L6)" "7.5/5.0(L6)")|Type="DP"|_REF_L4=("7.5/5.0(L4)")|_REF_L3=("7.0/5.0(L3)" "7.5/5.0(L3)")|imp="70.0"|_REF_L8=("7.0/5.0(L8)") | ByImpedance:72.0@_REF_L1=("7.0/5.5(L1)")|_REF_L5GND=("7.0/5.0(L5GND)")|_REF_L6=("7.0/5.0(L6)" "6.5/5.0(L6)")|Type="DP"|_REF_L4=("7.0/5.0(L4)")|_REF_L3=("7.0/5.0(L3)" "6.5/5.0(L3)")|imp="72.0"|_REF_L8=("7.0/5.5(L8)") | ByImpedance:75.0@_REF_L1=("6.5/5.0(L1)")|_REF_L5GND=("6.5/5.0(L5GND)")|_REF_L6=("6.5/5.0(L6)" "6.0/5.0(L6)")|Type="DP"|_REF_L4=("6.5/5.0(L4)")|_REF_L3=("6.5/5.0(L3)" "6.0/5.0(L3)")|imp="75.0"|_REF_L8=("6.5/5.0(L8)") | ByImpedance:80.0@_REF_L1=("5.5/5.0(L1)" "5.0/4.5(L1)" "6.0/6.0(L1)")|_REF_L5GND=("5.5/5.0(L5GND)")|_REF_L6=("5.0/5.0(L6)" "5.5/5.0(L6)")|Type="DP"|_REF_L4=("5.5/5.0(L4)")|_REF_L3=("5.5/5.0(L3)" "5.0/5.0(L3)")|imp="80.0"|_REF_L8=("4.5/56.0(L8)" "5.5/5.0(L8)") | ByImpedance:82.5@_REF_L1=("5.0/5.0(L1)")|_REF_L5GND=("5.0/5.0(L5GND)")|_REF_L6=("4.5/4.5(L6)")|Type="DP"|_REF_L4=("5.0/5.0(L4)")|_REF_L3=("4.5/4.5(L3)")|imp="82.5"|_REF_L8=("5.0/5.0(L8)") | ByImpedance:85.0@_REF_L1=("4.0/4.0(L1)" "5.0/6.0(L1)")|_REF_L5GND=("4.0/4.0(L5GND)" "5.0/6.0(L5GND)")|_REF_L6=("4.0/4.0(L6)" "5.0/6.0(L6)" "4.0/4.5(L6)" "5.0/5.0(L6)")|Type="DP"|_REF_L4=("4.0/4.0(L4)" "5.0/6.0(L4)")|_REF_L3=("4.0/4.0(L3)" "5.0/6.0(L3)" "5.0/5.0(L3)" "4.0/4.5(L3)")|imp="85.0"|_REF_L8=("4.0/4.0(L8)" "5.0/6.0(L8)") | ByImpedance:88.0@_REF_L1=("4.0/4.5(L1)")|_REF_L5GND=("4.0/4.5(L5GND)")|_REF_L6=("4.0/5.0(L6)" "4.0/4.5(L6)")|Type="DP"|_REF_L4=("4.0/4.5(L4)")|_REF_L3=("4.0/5.0(L3)" "4.0/4.5(L3)")|imp="88.0"|_REF_L8=("4.0/4.5(L8)") | ByImpedance:90.0@_REF_L1=("4.0/5.0(L1)")|_REF_L5GND=("4.0/5.0(L5GND)" "5.0/7.0(L5GND)")|_REF_L6=("7.0/5.0(L6)" "4.0/5.0(L6)")|Type="DP"|_REF_L4=("4.0/5.0(L4)" "5.0/7.0(L4)")|_REF_L3=("4.0/5.0(L3)" "4.0/6.0(L3)" "5.0/7.0(L3)")|imp="90.0"|_REF_L8=("4.0/5.0(L8)") | LayerIndex:nil | Source:8-1.2-3k.xls | artWorks:("_REF_L3" "_REF_L6" "_REF_L5GND" "_REF_L4" "_REF_L8" "_REF_L1") | gtImpOutlineUsed:BOARD GEOMETRY/PANEL_OUTLINE
User.31: 0 | 16 | 51 | 59 | 47 | 39 | 63 | 20
User.32: 8 | 118 | 126 | 181 | 161 | 59 | 49 | 79
User.33: AUD_AGND | 5V_S5 | VCC_CORE | +VCCGT | GND | +VCCIO | +VCCPRIM_CORE | 5V_S0
User.34: GND
User.36: AUD_AGND | GND
User.37: AUD_AGND | GND
User.38: AUD_AGND | GND | 5V_S5 | 3D3V_S5
User.43: This gerber is just for your reference to find the DP impedance traces in layer L1. | DP IMPEDANCE TABLE: L1 | * - Denotes that this Impedance | is NOT used | IMP(Ohm) | *60.0 | *65.0 | *70.0 | *72.0 | *75.0 | *80.0 | *82.5 | 85.0 | *85.0 | *88.0 | *90.0 | *100.0 | *110.0 | WIDTH(mils) | 9.5/5.0 | 8.5/5.0 | 7.0/5.0 | 7.0/5.5 | 6.5/5.0 | 5.5/5.0 | 5.0/4.5 | 6.0/6.0 | 5.0/5.0 | 4.0/4.0 | 5.0/6.0 | 4.0/4.5 | 4.0/5.0 | 4.0/10.0 | 3.5/7.0 | nil | TYPE | DP
User.45: This gerber is just for you reference to find the differential traces in layer BOTTOM | This gerber is just for you reference to find the differential traces in layer L3 | This gerber is just for you reference to find the differential traces in layer L4 | This gerber is just for you reference to find the differential traces in layer L6 | This gerber is just for you reference to find the differential traces in layer TOP | Note:Refer to DRILL layer for ELLIPSE drill direction | FIGURE | SIZE | 10.0 | 16.0 | 20.0 | 28.0 | 32.0 | 40.0 | 128.0 | 178.0 | 229.0 | 38.0 | 44.0 | 63.0 | 86.0 | 103.0 | 48.0x28.0 | 60.0x24.0 | 79.0x28.0 | 93.0x32.0 | 95.0x28.0 | 103.0x28.0 | 106.0x28.0 | 126.0x102.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 2607 | 588 | 19 | 10 | 9 | 8 | 3 | 2 | 1 | 7 | This gerber is just for your reference to find the DP impedance traces in layer L3. | This gerber is just for your reference to find the DP impedance traces in layer L4. | This gerber is just for your reference to find the DP impedance traces in layer L5GND. | This gerber is just for your reference to find the DP impedance traces in layer L6. | This gerber is just for your reference to find the DP impedance traces in layer L8. | This gerber is just for your reference to find the SE impedance traces in layer L1. | This gerber is just for your reference to find the SE impedance traces in layer L3. | This gerber is just for your reference to find the SE impedance traces in layer L4. | This gerber is just for your reference to find the SE impedance traces in layer L5GND. | This gerber is just for your reference to find the SE impedance traces in layer L6. | This gerber is just for your reference to find the SE impedance traces in layer L8. | DP IMPEDANCE TABLE: L3 | DP IMPEDANCE TABLE: L4 | DP IMPEDANCE TABLE: L5GND | DP IMPEDANCE TABLE: L6 | DP IMPEDANCE TABLE: L8 | SE IMPEDANCE TABLE: L1 | SE IMPEDANCE TABLE: L3 | SE IMPEDANCE TABLE: L4 | SE IMPEDANCE TABLE: L5GND | SE IMPEDANCE TABLE: L6 | SE IMPEDANCE TABLE: L8 | * - Denotes that this Impedance | is NOT used | Model | COTTONWOOD MLK MB | PCB_NO | 14275 | VER. | Layer | DRILL | L1 | L2VCC | L3 | L4 | TMASK | TPLACE | TSILK | TSMD | Designer | Joy | IMP(Ohm) | *33.0 | *60.0 | *35.0 | *65.0 | *37.5 | *70.0 | *39.0 | *72.0 | *40.0 | *75.0 | *45.0 | *80.0 | *48.0 | *82.5 | *50.0 | *85.0 | 50.0 | 85.0 | *55.0 | *88.0 | *90.0 | *100.0 | *110.0 | Date | 07/27/2015 | WIDTH(mils) | 10.5 | 9.0 | 9.5 | 8.0 | 8.5 | 7.5 | 7.0 | 5.5 | 6.0 | 5.0 | 4.5 | 3.5 | 6.5 | 4.0 | 10.0/5.0 | 9.5/5.0 | 8.5/5.0 | 7.0/5.0 | 7.5/5.0 | 8.0/5.0 | 7.0/5.5 | 6.5/5.0 | 4.5/56.0 | 5.5/5.0 | 5.0/5.0 | 4.0/4.0 | 5.0/6.0 | 4.0/4.5 | 6.0/5.0 | 4.0/5.0 | 5.0/7.0 | 4.0/10.0 | 4.0/9.0 | 4.5/4.5 | 3.5/7.0 | nil | 4.0/6.0 | 4.0/12.0 | 3.5/8.0 | TYPE | SE | DP | BMASK | BPLACE | BSILK | BSMD | L5GND | L6 | L7GND | L8
